Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:05:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:05:23 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{9F9BC020-17E4-4CD9-B87A-2FB70296DBA4}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:05:23 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:05:23 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:05:23 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: RAL7035, КНС_ИнформационнаяРозеткаНаDINРейкуCAT6AKeystone_DKC:RAL7035, 0 В, Однофазная Тип системы, 2 Провода:789322
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: RNK6AFSDIN; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1382/RNK6AFSDIN/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; Описание: Назначение • для установки в шкафы автоматики; • для установки на стену. Совместимость с компонентами • коммутационные панели с разъемами RJ45; • розеточные модули с разъемами RJ45; Отличительные особенности • в комплекте предусмотрено крепление на DIN-рейку; • экранированный модуль CAT 6А стандарта RJ45, тип 8Р8С в комплекте; • специальное поле для маркировки; • удобная шторка на пружине. Температурные диапазоны • хранение: от -40 до +70 °C; • эксплуатация: от -40 до +70 °C; • монтаж: от 0 до +70 °C. Упаковка • коробка/пакет, 12 шт.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
