Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:36:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:36:56 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{70D9774F-A645-44E6-8CCC-83F1F3515683}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:36:55 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:36:55 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:36:55 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: M16х1,5 D5-10мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M16х1,5 D5-10мм_Нержавеющая сталь AISI316L:610496
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M16х1,5 D5-10мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M16х1,5 D5-10мм_Никелированная латунь:610472
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм_Никелированная латунь

# IfcFlowFitting: M20х1,5 D5,5-13мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M20х1,5 D5,5-13мм_Нержавеющая сталь AISI316L:610498
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D5,5-13мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M20х1,5 D5,5-13мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M20х1,5 D5,5-13мм_Никелированная латунь:610476
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D5,5-13мм_Никелированная латунь

# IfcFlowFitting: M25х1,5 D10,5-18мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M25х1,5 D10,5-18мм_Нержавеющая сталь AISI316L:610500
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M25х1,5 D10,5-18мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M25х1,5 D10,5-18мм_Никелированная латунь:610479
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм_Никелированная латунь

# IfcFlowFitting: M32х1,5 D15-24мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M32х1,5 D15-24мм_Нержавеющая сталь AISI316L:610502
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M32х1,5 D15-24мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M32х1,5 D15-24мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M32х1,5 D15-24мм_Никелированная латунь:610482
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M32х1,5 D15-24мм_Никелированная латунь

# IfcFlowFitting: M40х1,5 D21-30мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M40х1,5 D21-30мм_Нержавеющая сталь AISI316L:610504
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M40х1,5 D21-30мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M40х1,5 D21-30мм_Никелированная латунь:610485
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм_Никелированная латунь

# IfcFlowFitting: M50х1,5 D24-36мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M50х1,5 D24-36мм_Нержавеющая сталь AISI316L:610506
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D24-36мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M50х1,5 D24-36мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M50х1,5 D24-36мм_Никелированная латунь:610488
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D24-36мм_Никелированная латунь

# IfcFlowFitting: M63х1,5 D36-45мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M63х1,5 D36-45мм_Нержавеющая сталь AISI316L:610508
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M63х1,5 D36-45мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M63х1,5 D36-45мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M63х1,5 D36-45мм_Никелированная латунь:610491
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M63х1,5 D36-45мм_Никелированная латунь

# IfcFlowFitting: M75х1,5 D45-54мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M75х1,5 D45-54мм_Нержавеющая сталь AISI316L:610510
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M75х1,5 D45-54мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M75х1,5 D45-54мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANF_DKC:M75х1,5 D45-54мм_Никелированная латунь:610494
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M75х1,5 D45-54мм_Никелированная латунь
