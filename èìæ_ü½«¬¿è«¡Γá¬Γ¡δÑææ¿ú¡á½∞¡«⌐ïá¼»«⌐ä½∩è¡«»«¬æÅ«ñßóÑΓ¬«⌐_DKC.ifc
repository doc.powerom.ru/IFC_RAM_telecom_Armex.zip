Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:29:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:29:58 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{A9E79EA7-5ACB-4658-8039-2E6222085F9D}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:29:58 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:29:58 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:29:58 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Схема 1NC_10V-28V AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NC_10V-28V AC/DC_Ex d e IIC Gb:597945
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NC_10V-28V AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.127.303; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 1NC_10V-28V AC/DC_Ex ia IIC Ga U, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NC_10V-28V AC/DC_Ex ia IIC Ga U:597950
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NC_10V-28V AC/DC_Ex ia IIC Ga U
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2362.127.300; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 1NC_20V-250V AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NC_20V-250V AC/DC_Ex d e IIC Gb:597951
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NC_20V-250V AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.127.301; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 1NC_50V-277 AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NC_50V-277 AC/DC_Ex d e IIC Gb:597952
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NC_50V-277 AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.127.304; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 1NO_10V-28V AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NO_10V-28V AC/DC_Ex d e IIC Gb:597953
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NO_10V-28V AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.127.403; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 1NO_10V-28V AC/DC_Ex ia IIC Ga U, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NO_10V-28V AC/DC_Ex ia IIC Ga U:598007
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NO_10V-28V AC/DC_Ex ia IIC Ga U
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2362.127.400; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 1NO_20V-250V AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NO_20V-250V AC/DC_Ex d e IIC Gb:598168
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NO_20V-250V AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.127.401; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 1NO_50V-277 AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеССигнальнойЛампойДляКнопокСПодсветкой_DKC:Схема 1NO_50V-277 AC/DC_Ex d e IIC Gb:598170
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NO_50V-277 AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.127.404; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для кнопки с подсветкой светофильтров для замыкания, размыкания и индикации электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • не комплектуется насадкой; Комментарии к типоразмеру: Взрывозащищита элемент управления
