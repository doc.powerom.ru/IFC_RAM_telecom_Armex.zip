Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:16:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:16:56 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{3AC5D0F3-FDFA-47AD-93EF-C391409ADC88}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:16:55 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:16:55 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:16:55 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2361.1100.614.00_Красный, КНС_Светофильтр_DKC:2361.1100.614.00_Красный:592686
In: Этаж 01
Type - Material: DKC_Стекло_Красное, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.1100.614.00_Красный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.1100.614.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • светофильтр для индикации работы электрической цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.1100.615.00_Зеленый, КНС_Светофильтр_DKC:2361.1100.615.00_Зеленый:592689
In: Этаж 01
Type - Material: DKC_Стекло_Зеленое, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.1100.615.00_Зеленый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.1100.615.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • светофильтр для индикации работы электрической цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.1100.616.00_Желтый, КНС_Светофильтр_DKC:2361.1100.616.00_Желтый:592690
In: Этаж 01
Type - Material: DKC_Стекло_Желтое, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.1100.616.00_Желтый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.1100.616.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • светофильтр для индикации работы электрической цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления
