Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:48:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:48:45 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{04E7E93E-166F-4EC7-8A56-321375FCC4B5}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:48:45 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:48:45 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:48:45 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: Муфта труба-труба (7)
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Муфта труба-труба
Name (КНС_ВзрывозащищеннаяМуфтаТруба-Труба_НикелированнаяЛатунь_DKC:Муфта труба-труба:...)
639025
639027
639029
639031
639033
639035
639037
