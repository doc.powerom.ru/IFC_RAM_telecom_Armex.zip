Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:31:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:31:22 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B89CF0DD-1160-403F-A327-0F5E9F5F9FCD}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:30:22 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:30:23 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:30:23 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 600х1000_Серый, КНС_НапольныйШкаф42U_DKC:600х1000_Серый:702945
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х1000_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4261GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4261GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х1000_Черный, КНС_НапольныйШкаф42U_DKC:600х1000_Черный:692864
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х1000_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4261GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4261GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х1200_Черный, КНС_НапольныйШкаф42U_DKC:600х1200_Черный:692865
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х1200_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4262GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4262GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х600_Серый, КНС_НапольныйШкаф42U_DKC:600х600_Серый:702943
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х600_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4266GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4266GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х600_Черный, КНС_НапольныйШкаф42U_DKC:600х600_Черный:692862
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х600_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4266GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4266GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х800_Серый, КНС_НапольныйШкаф42U_DKC:600х800_Серый:702944
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х800_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4268GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4268GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х800_Черный, КНС_НапольныйШкаф42U_DKC:600х800_Черный:692863
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х800_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4268GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4268GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1000_Серый, КНС_НапольныйШкаф42U_DKC:800х1000_Серый:702948
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х1000_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4281GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4281GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1000_Черный, КНС_НапольныйШкаф42U_DKC:800х1000_Черный:692867
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х1000_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4281GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4281GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1200_Черный, КНС_НапольныйШкаф42U_DKC:800х1200_Черный:692868
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х1200_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4282GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4282GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х800_Серый, КНС_НапольныйШкаф42U_DKC:800х800_Серый:702947
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х800_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4288GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4288GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х800_Черный, КНС_НапольныйШкаф42U_DKC:800х800_Черный:692866
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х800_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4288GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4288GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: RAL7035 (10)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
Name (КНС_ОрганизаторВоздушныхПотоков_DKC:RAL7035:...) | ADSK_Код изделия
702950 | R5VRU426075
702951 | R5VRU426075
702956 | R5VRU426075
702957 | R5VRU426075
702962 | R5VRU426075
702963 | R5VRU426075
702974 | R5VRU428075
702975 | R5VRU428075
702980 | R5VRU428075
702981 | R5VRU428075

# IfcBuildingElementProxy: RAL9005 (14)
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
Name (КНС_ОрганизаторВоздушныхПотоков_DKC:RAL9005:...) | ADSK_Код изделия
692869 | R5VRU426075B
692870 | R5VRU426075B
692875 | R5VRU426075B
692876 | R5VRU426075B
692881 | R5VRU426075B
692882 | R5VRU426075B
692887 | R5VRU426075B
692888 | R5VRU426075B
692893 | R5VRU428075B
692894 | R5VRU428075B
692899 | R5VRU428075B
692900 | R5VRU428075B
692905 | R5VRU428075B
692906 | R5VRU428075B
