Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:04:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:04:34 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{7828FE94-7B65-484B-8733-DC67F5C85319}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:04:33 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:04:33 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:04:33 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 10U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:10U_RAL7035:786896
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 10U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN10; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN10/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 10U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:10U_RAL9005:787136
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 10U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN10B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN10B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 11U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:11U_RAL7035:786899
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 11U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN11; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN11/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 11U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:11U_RAL9005:787137
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 11U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN11B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN11B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 12U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:12U_RAL7035:786902
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 12U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN12; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN12/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 12U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:12U_RAL9005:787138
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 12U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN12B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN12B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 1U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:1U_RAL7035:786654
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 1U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN1; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN1/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 1U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:1U_RAL9005:787125
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 1U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN1B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN1B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 2U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:2U_RAL7035:786862
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 2U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN2; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN2/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 2U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:2U_RAL9005:787128
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 2U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN2B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN2B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 3U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:3U_RAL7035:786875
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 3U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN3; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN3/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 3U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:3U_RAL9005:787129
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 3U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN3B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN3B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 4U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:4U_RAL7035:786878
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 4U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN4; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN4/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 4U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:4U_RAL9005:787130
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 4U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN4B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN4B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 5U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:5U_RAL7035:786881
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 5U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN5; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN5/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 5U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:5U_RAL9005:787131
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 5U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN5B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN5B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 6U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:6U_RAL7035:786884
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 6U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN6; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN6/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 6U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:6U_RAL9005:787132
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 6U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN6B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN6B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 7U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:7U_RAL7035:786887
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 7U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN7; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN7/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 7U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:7U_RAL9005:787133
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 7U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN7B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN7B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 8U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:8U_RAL7035:786890
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 8U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN8; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN8/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 8U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:8U_RAL9005:787134
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 8U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN8B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN8B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 9U_RAL7035, КНС_ЗаглушкиГоризонтальные_DKC:9U_RAL7035:786893
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 9U_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN9; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN9/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 9U_RAL9005, КНС_ЗаглушкиГоризонтальные_DKC:9U_RAL9005:787135
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 9U_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PRKN9B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PRKN9B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • материал – сталь 2 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • поставляется в комплекте с крепежом; • ребра жесткости предохраняют панель от деформации.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
