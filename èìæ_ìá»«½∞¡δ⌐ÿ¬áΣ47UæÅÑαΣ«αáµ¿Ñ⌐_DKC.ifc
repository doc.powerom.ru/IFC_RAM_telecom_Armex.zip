Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:40:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:40:11 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{96A9838D-0655-458E-B809-AF0F47FDD169}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:39:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:39:05 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:39:05 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 600х1000_Серый, КНС_НапольныйШкаф47UСПерфорацией_DKC:600х1000_Серый:733309
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 600х1000_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4761PF; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4761PF/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х1000_Черный, КНС_НапольныйШкаф47UСПерфорацией_DKC:600х1000_Черный:713043
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 600х1000_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4761PFB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4761PFB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х1200_Черный, КНС_НапольныйШкаф47UСПерфорацией_DKC:600х1200_Черный:713044
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 600х1200_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4762PFB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4762PFB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х600_Серый, КНС_НапольныйШкаф47UСПерфорацией_DKC:600х600_Серый:733307
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 600х600_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4766PF; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4766PF/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х600_Черный, КНС_НапольныйШкаф47UСПерфорацией_DKC:600х600_Черный:713041
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 600х600_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4766PFB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4766PFB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х800_Серый, КНС_НапольныйШкаф47UСПерфорацией_DKC:600х800_Серый:733308
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 600х800_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4768PF; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4768PF/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х800_Черный, КНС_НапольныйШкаф47UСПерфорацией_DKC:600х800_Черный:713042
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 600х800_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4768PFB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4768PFB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1000_Серый, КНС_НапольныйШкаф47UСПерфорацией_DKC:800х1000_Серый:733312
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 800х1000_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4781PF; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4781PF/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1000_Черный, КНС_НапольныйШкаф47UСПерфорацией_DKC:800х1000_Черный:713046
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 800х1000_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4781PFB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4781PFB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1200_Черный, КНС_НапольныйШкаф47UСПерфорацией_DKC:800х1200_Черный:713047
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 800х1200_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4782PFB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4782PFB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х800_Серый, КНС_НапольныйШкаф47UСПерфорацией_DKC:800х800_Серый:733311
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 800х800_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4788PF; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4788PF/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х800_Черный, КНС_НапольныйШкаф47UСПерфорацией_DKC:800х800_Черный:713045
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Металл_Перфорация
Pset_BuildingElementProxyCommon - Reference: 800х800_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT4788PFB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT4788PFB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: RAL7035 (10)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
Name (КНС_ОрганизаторВоздушныхПотоков_DKC:RAL7035:...) | ADSK_Код изделия
733314 | R5VRP476010
733315 | R5VRP476010
733320 | R5VRP476010
733321 | R5VRP476010
733326 | R5VRP476010
733327 | R5VRP476010
733338 | R5VRP478010
733339 | R5VRP478010
733344 | R5VRP478010
733345 | R5VRP478010

# IfcBuildingElementProxy: RAL9005 (14)
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
Name (КНС_ОрганизаторВоздушныхПотоков_DKC:RAL9005:...) | ADSK_Код изделия
713048 | R5VRP476010B
713049 | R5VRP476010B
713054 | R5VRP476010B
713055 | R5VRP476010B
713060 | R5VRP476010B
713061 | R5VRP476010B
713066 | R5VRP476010B
713067 | R5VRP476010B
713072 | R5VRP478010B
713073 | R5VRP478010B
713078 | R5VRP478010B
713079 | R5VRP478010B
713084 | R5VRP478010B
713085 | R5VRP478010B
