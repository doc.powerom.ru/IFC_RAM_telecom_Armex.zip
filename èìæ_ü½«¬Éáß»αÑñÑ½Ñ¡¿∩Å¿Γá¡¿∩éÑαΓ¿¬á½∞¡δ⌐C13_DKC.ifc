Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:52:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:52:22 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B16EC952-EB22-40BB-AA84-826FE4DEE10E}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:52:20 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:52:20 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:52:20 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 10A с автоматом 2P и защитой_Вых 12ХС13_Вх С14Х20м, КНС_БлокРаспределенияПитанияВертикальныйC13_DKC:10A с автоматом 2P и защитой_Вых 12ХС13_Вх С14Х20м:941226
In: Этаж 01
Type - Material: DKC_Термопласт_Черный
Pset_BuildingElementProxyCommon - Reference: 10A с автоматом 2P и защитой_Вых 12ХС13_Вх С14Х20м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5VIEC12CBOP; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5VIEC12CBOP/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000330; Описание: Основные характеристики • номинальное напряжение 230 В; • номинальная сила тока 10/16 А; • разъемы Schuko / С13 / C14 / C20 / С19; • монтаж вертикальный; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 10A с индикацией и защитой_Вых 11ХС13_Вх С14Х2м, КНС_БлокРаспределенияПитанияВертикальныйC13_DKC:10A с индикацией и защитой_Вых 11ХС13_Вх С14Х2м:941497
In: Этаж 01
Type - Material: DKC_Термопласт_Черный
Pset_BuildingElementProxyCommon - Reference: 10A с индикацией и защитой_Вых 11ХС13_Вх С14Х2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5VIEC11CDOP; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5VIEC11CDOP/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000330; Описание: Основные характеристики • номинальное напряжение 230 В; • номинальная сила тока 10/16 А; • разъемы Schuko / С13 / C14 / C20 / С19; • монтаж вертикальный; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 10A с индикацией и защитой_Вых10ХС13_Вх С14Х2м, КНС_БлокРаспределенияПитанияВертикальныйC13_DKC:10A с индикацией и защитой_Вых10ХС13_Вх С14Х2м:941402
In: Этаж 01
Type - Material: DKC_Термопласт_Черный, DKC_Стекло_Красное
Pset_BuildingElementProxyCommon - Reference: 10A с индикацией и защитой_Вых10ХС13_Вх С14Х2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519IEC10SWCD; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519IEC10SWCD/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000330; Описание: Основные характеристики • номинальное напряжение 230 В; • номинальная сила тока 10/16 А; • разъемы Schuko / С13 / C14 / C20 / С19; • монтаж вертикальный; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 10A с индикацией_Вых 24ХС13_Вх С14Х2м, КНС_БлокРаспределенияПитанияВертикальныйC13_DKC:10A с индикацией_Вых 24ХС13_Вх С14Х2м:941602
In: Этаж 01
Type - Material: DKC_Термопласт_Черный
Pset_BuildingElementProxyCommon - Reference: 10A с индикацией_Вых 24ХС13_Вх С14Х2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5VIEC24PIC14; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5VIEC24PIC14/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000330; Описание: Основные характеристики • номинальное напряжение 230 В; • номинальная сила тока 10/16 А; • разъемы Schuko / С13 / C14 / C20 / С19; • монтаж вертикальный; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
