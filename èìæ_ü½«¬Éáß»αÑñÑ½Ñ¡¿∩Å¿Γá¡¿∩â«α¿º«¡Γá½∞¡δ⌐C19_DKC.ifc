Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:51:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:51:37 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{6DC80C8D-426E-4EE7-BAD5-A246202F1AC0}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:51:36 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:51:36 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:51:36 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 16A_Вых 6 ХC19_Вх C20х2м, КНС_БлокРаспределенияПитанияГоризонтальныйC19_DKC:16A_Вых 6 ХC19_Вх C20х2м:940907
In: Этаж 01
Type - Material: DKC_Термопласт_Черный
Pset_BuildingElementProxyCommon - Reference: 16A_Вых 6 ХC19_Вх C20х2м
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519C146; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519C146/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000330; Описание: Основные характеристики • номинальное напряжение 230 В; • номинальная сила тока 10/16 А; • разъемы Schuko / С13 / C14 / C20 / С19; • монтаж 19 дюймов; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
