Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:30:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:30:44 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{2ECBEFAD-D675-4DBC-937B-E85408F82750}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:30:43 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:30:44 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:30:44 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: GAS_AISI 316L (9)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: GAS_AISI 316L
Name (КНС_ВзрывозащищеннаяЗаглушка_DKC:GAS_AISI 316L:...)
603464
603516
603525
603555
603563
603571
603579
603587
603595

# IfcFlowFitting: GAS_Никелированная латунь (9)
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: GAS_Никелированная латунь
Name (КНС_ВзрывозащищеннаяЗаглушка_DKC:GAS_Никелированная латунь:...)
603225
603514
603523
603553
603561
603569
603577
603585
603593

# IfcFlowFitting: NPT_AISI 316L (9)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: NPT_AISI 316L
Name (КНС_ВзрывозащищеннаяЗаглушка_DKC:NPT_AISI 316L:...)
603846
603850
603855
603860
603865
603870
603875
603880
603885

# IfcFlowFitting: NPT_Никелированная латунь (9)
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: NPT_Никелированная латунь
Name (КНС_ВзрывозащищеннаяЗаглушка_DKC:NPT_Никелированная латунь:...)
603844
603848
603853
603858
603863
603868
603873
603878
603883

# IfcFlowFitting: Метрическая_AISI 316L (9)
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Метрическая_AISI 316L
Name (КНС_ВзрывозащищеннаяЗаглушка_DKC:Метрическая_AISI 316L:...)
604529
604531
604533
604535
604537
604539
604541
604543
604545

# IfcFlowFitting: Метрическая_Никелированная латунь (9)
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Метрическая_Никелированная латунь
Name (КНС_ВзрывозащищеннаяЗаглушка_DKC:Метрическая_Никелированная латунь:...)
603977
603981
603986
603991
603996
604001
604006
604011
604016
