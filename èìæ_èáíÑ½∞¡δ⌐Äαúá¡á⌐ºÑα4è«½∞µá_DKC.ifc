Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:02:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:02:19 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{D8453926-8DB3-4924-B191-9753CF4CFABD}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:02:18 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:02:18 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:02:18 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: C отверстиями_RAL7035, КНС_КабельныйОрганайзер4Кольца_DKC:C отверстиями_RAL7035, 0 В, Однофазная Тип системы, 2 Провода:783754
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: C отверстиями_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PCF191HE; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PCF191HE/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002624; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • четыре кольца на лицевой стороне для укладки шнуров и кабелей; • размеры колец по внутренней стороне 40х80 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • крепежные элементы (винт М6х14, шайба, закладная гайка) входят в комплект поставки; • номинальная высота 1U (44,45 мм); • геометрическая высота 40 мм.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: C отверстиями_RAL9005, КНС_КабельныйОрганайзер4Кольца_DKC:C отверстиями_RAL9005, 0 В, Однофазная Тип системы, 2 Провода:783755
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: C отверстиями_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PCF191HEB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PCF191HEB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002624; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • четыре кольца на лицевой стороне для укладки шнуров и кабелей; • размеры колец по внутренней стороне 40х80 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • крепежные элементы (винт М6х14, шайба, закладная гайка) входят в комплект поставки; • номинальная высота 1U (44,45 мм); • геометрическая высота 40 мм.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: RAL7035, КНС_КабельныйОрганайзер4Кольца_DKC:RAL7035, 0 В, Однофазная Тип системы, 2 Провода:783750
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PC191HE; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PC191HE/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002624; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • четыре кольца на лицевой стороне для укладки шнуров и кабелей; • размеры колец по внутренней стороне 40х80 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • крепежные элементы (винт М6х14, шайба, закладная гайка) входят в комплект поставки; • номинальная высота 1U (44,45 мм); • геометрическая высота 40 мм.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: RAL9005, КНС_КабельныйОрганайзер4Кольца_DKC:RAL9005, 0 В, Однофазная Тип системы, 2 Провода:783753
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5PC191HEB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5PC191HEB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002624; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • четыре кольца на лицевой стороне для укладки шнуров и кабелей; • размеры колец по внутренней стороне 40х80 мм; • окрашены методом нанесения полимерно-порошкового покрытия RAL 9005 или RAL 7035; • крепежные элементы (винт М6х14, шайба, закладная гайка) входят в комплект поставки; • номинальная высота 1U (44,45 мм); • геометрическая высота 40 мм.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
