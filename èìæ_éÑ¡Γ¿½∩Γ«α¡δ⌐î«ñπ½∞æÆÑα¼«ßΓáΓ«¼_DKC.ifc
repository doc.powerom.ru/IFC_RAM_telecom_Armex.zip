Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:04:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:04:56 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{0E99C24B-787D-4BC6-AF69-61752F82668D}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:04:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:04:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:04:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 4 вентилятора_RAL7035, КНС_ВентиляторныйМодульСТермостатом_DKC:4 вентилятора_RAL7035:788323
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 4 вентилятора_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519VSIT4FT; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519VSIT4FT/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • количество вентиляторов в блоке - от 4, 6 или 9; • корпус изготовлен из стального проката толщиной 1,5 мм; • комплект поставки: – шнур питания 3х0,75 мм2, длина 1,8 м; – разъемы Schuko и C13; – крепеж (закладные гайки, шайбы и винты М6х16); – упаковка – картонная коробка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 4 вентилятора_RAL9005, КНС_ВентиляторныйМодульСТермостатом_DKC:4 вентилятора_RAL9005:788328
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 4 вентилятора_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519VSIT4FTB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519VSIT4FTB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • количество вентиляторов в блоке - от 4, 6 или 9; • корпус изготовлен из стального проката толщиной 1,5 мм; • комплект поставки: – шнур питания 3х0,75 мм2, длина 1,8 м; – разъемы Schuko и C13; – крепеж (закладные гайки, шайбы и винты М6х16); – упаковка – картонная коробка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 6 вентиляторов_RAL7035, КНС_ВентиляторныйМодульСТермостатом_DKC:6 вентиляторов_RAL7035:788329
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 6 вентиляторов_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519VSIT6FT; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519VSIT6FT/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • количество вентиляторов в блоке - от 4, 6 или 9; • корпус изготовлен из стального проката толщиной 1,5 мм; • комплект поставки: – шнур питания 3х0,75 мм2, длина 1,8 м; – разъемы Schuko и C13; – крепеж (закладные гайки, шайбы и винты М6х16); – упаковка – картонная коробка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 6 вентиляторов_RAL9005, КНС_ВентиляторныйМодульСТермостатом_DKC:6 вентиляторов_RAL9005:788326
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 6 вентиляторов_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519VSIT6FTB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519VSIT6FTB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • количество вентиляторов в блоке - от 4, 6 или 9; • корпус изготовлен из стального проката толщиной 1,5 мм; • комплект поставки: – шнур питания 3х0,75 мм2, длина 1,8 м; – разъемы Schuko и C13; – крепеж (закладные гайки, шайбы и винты М6х16); – упаковка – картонная коробка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 9 вентиляторов_RAL7035, КНС_ВентиляторныйМодульСТермостатом_DKC:9 вентиляторов_RAL7035:788404
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 9 вентиляторов_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519VSIT9FT; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519VSIT9FT/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • количество вентиляторов в блоке - от 4, 6 или 9; • корпус изготовлен из стального проката толщиной 1,5 мм; • комплект поставки: – шнур питания 3х0,75 мм2, длина 1,8 м; – разъемы Schuko и C13; – крепеж (закладные гайки, шайбы и винты М6х16); – упаковка – картонная коробка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 9 вентиляторов_RAL9005, КНС_ВентиляторныйМодульСТермостатом_DKC:9 вентиляторов_RAL9005:788402
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 9 вентиляторов_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R519VSIT9FTB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R519VSIT9FTB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • количество вентиляторов в блоке - от 4, 6 или 9; • корпус изготовлен из стального проката толщиной 1,5 мм; • комплект поставки: – шнур питания 3х0,75 мм2, длина 1,8 м; – разъемы Schuko и C13; – крепеж (закладные гайки, шайбы и винты М6х16); – упаковка – картонная коробка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
