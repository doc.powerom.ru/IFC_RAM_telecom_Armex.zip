Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:55:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:55:07 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{EC830256-E526-49FA-99C0-83E4F89D7A89}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:55:07 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:55:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:55:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: Переходник М20х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М20х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L:652572
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М20х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М20х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М20х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь:651977
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М20х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М20х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М20х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L:652574
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М20х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М20х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М20х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь:651979
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М20х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М20х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М20х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L:652576
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М20х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М20х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М20х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь:651981
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М20х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L:652578
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь:651983
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L:652580
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь:651985
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L:652582
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь:651987
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_AISI 316L:652584
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М25х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М25х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_Никелированная латунь:651989
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М25х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L:652586
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь:651991
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L:652598
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь:652004
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L:652588
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь:651993
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М40х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_AISI 316L:652590
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М32х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М32х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_Никелированная латунь:651995
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М32х1,5 (наружн. резьба)/ М50х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М40х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М40х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L:652592
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М40х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М40х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М40х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь:651998
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М40х1,5 (наружн. резьба)/ М20х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М40х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М40х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L:652594
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М40х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М40х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М40х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь:652000
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М40х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М40х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М40х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L:653261
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М40х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М50х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М50х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L:652596
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М50х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М50х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М50х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь:652002
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М50х1,5 (наружн. резьба)/ М25х1,5 (внутр. резьба)_Никелированная латунь

# IfcFlowFitting: Переходник М50х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М50х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L:652600
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М50х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_AISI 316L

# IfcFlowFitting: Переходник М50х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь, КНС_ВзрывозащищенныйПереходникНаружнаяРезьба-ВнутренняяРезьба_DKC:Переходник М50х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь:652079
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: Переходник М50х1,5 (наружн. резьба)/ М32х1,5 (внутр. резьба)_Никелированная латунь
