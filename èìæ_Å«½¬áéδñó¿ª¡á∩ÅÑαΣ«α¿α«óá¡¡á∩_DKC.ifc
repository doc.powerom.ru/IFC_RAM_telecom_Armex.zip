Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:50:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:50:06 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{84BEA30B-9916-4257-B118-4965AB023760}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:50:05 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:50:06 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:50:06 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 285мм_RAL7035, КНС_ПолкаВыдвижнаяПерфорированная_DKC:285мм_RAL7035:739900
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 285мм_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5REIT6860; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5REIT6860/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002620; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • установка на передние и задние 19-дюймовые профили; • максимальная нагрузка 60 кг; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 300мм_RAL9005, КНС_ПолкаВыдвижнаяПерфорированная_DKC:300мм_RAL9005:739905
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 300мм_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5REIT6860B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5REIT6860B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002620; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • установка на передние и задние 19-дюймовые профили; • максимальная нагрузка 60 кг; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 485мм_RAL7035, КНС_ПолкаВыдвижнаяПерфорированная_DKC:485мм_RAL7035:739901
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 485мм_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5REIT6880; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5REIT6880/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002620; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • установка на передние и задние 19-дюймовые профили; • максимальная нагрузка 60 кг; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 485мм_RAL9005, КНС_ПолкаВыдвижнаяПерфорированная_DKC:485мм_RAL9005:739906
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 485мм_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5REIT6880B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5REIT6880B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002620; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • установка на передние и задние 19-дюймовые профили; • максимальная нагрузка 60 кг; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 685мм_RAL7035, КНС_ПолкаВыдвижнаяПерфорированная_DKC:685мм_RAL7035:739902
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 685мм_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5REIT68100; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5REIT68100/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002620; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • установка на передние и задние 19-дюймовые профили; • максимальная нагрузка 60 кг; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 685мм_RAL9005, КНС_ПолкаВыдвижнаяПерфорированная_DKC:685мм_RAL9005:739994
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: 685мм_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5REIT68100B; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5REIT68100B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002620; Описание: Основные характеристики • материал – стальной прокат толщиной 1,5 мм; • установка на передние и задние 19-дюймовые профили; • максимальная нагрузка 60 кг; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
