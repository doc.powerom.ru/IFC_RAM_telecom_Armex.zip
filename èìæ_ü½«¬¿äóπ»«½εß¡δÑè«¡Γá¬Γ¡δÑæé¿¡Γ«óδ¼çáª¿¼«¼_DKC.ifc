Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:17:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:17:48 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{3875DE5A-C451-4C1B-9EBD-68FE4B082056}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:17:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:17:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:17:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Схема 1NC/1NO, КНС_БлокиДвуполюсныеКонтактныеСВинтовымЗажимом_DKC:Схема 1NC/1NO:595686
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 1NC/1NO
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.017.000; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для управляющих насадок и переключателей для замыкания и размыкания электрических цепей управления; • устанавливается на крышку взрывозащищенной оболочки. Электрические характеристики • 400 V / 16 A (AC-12); • 400 V / 10 A (AC-15); • 110 V / 1 A (DC-13); • 400 V / 16 A (AC-3); • 400 V / 16 A (AC-23). Комплектация • не комплектуется насадками и переключателями; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 2NC, КНС_БлокиДвуполюсныеКонтактныеСВинтовымЗажимом_DKC:Схема 2NC:595687
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 2NC
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.017.001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для управляющих насадок и переключателей для замыкания и размыкания электрических цепей управления; • устанавливается на крышку взрывозащищенной оболочки. Электрические характеристики • 400 V / 16 A (AC-12); • 400 V / 10 A (AC-15); • 110 V / 1 A (DC-13); • 400 V / 16 A (AC-3); • 400 V / 16 A (AC-23). Комплектация • не комплектуется насадками и переключателями; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: Схема 2NO, КНС_БлокиДвуполюсныеКонтактныеСВинтовымЗажимом_DKC:Схема 2NO:595688
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Схема 2NO
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.017.002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для управляющих насадок и переключателей для замыкания и размыкания электрических цепей управления; • устанавливается на крышку взрывозащищенной оболочки. Электрические характеристики • 400 V / 16 A (AC-12); • 400 V / 10 A (AC-15); • 110 V / 1 A (DC-13); • 400 V / 16 A (AC-3); • 400 V / 16 A (AC-23). Комплектация • не комплектуется насадками и переключателями; Комментарии к типоразмеру: Взрывозащищита элемент управления
