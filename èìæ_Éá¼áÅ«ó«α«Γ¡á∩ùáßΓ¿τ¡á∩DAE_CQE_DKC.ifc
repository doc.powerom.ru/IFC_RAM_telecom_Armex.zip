Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:56:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:56:27 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{6CD94B1E-DE66-472F-BAC5-480685DC1E5B}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:56:23 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:56:24 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:56:24 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: частичная 12U Ш=800мм, КНС_РамаПоворотнаяЧастичнаяDAE_CQE_DKC:частичная 12U Ш=800мм:756169
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: частичная 12U Ш=800мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIEP12; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIEP12/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: частичная 16U Ш=800мм, КНС_РамаПоворотнаяЧастичнаяDAE_CQE_DKC:частичная 16U Ш=800мм:756168
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: частичная 16U Ш=800мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIEP16; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIEP16/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: частичная 18U Ш=800мм, КНС_РамаПоворотнаяЧастичнаяDAE_CQE_DKC:частичная 18U Ш=800мм:756532
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: частичная 18U Ш=800мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIEP18; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIEP18/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: частичная 6U Ш=800мм, КНС_РамаПоворотнаяЧастичнаяDAE_CQE_DKC:частичная 6U Ш=800мм:756166
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: частичная 6U Ш=800мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIEP6; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIEP6/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: частичная 9U Ш=800мм, КНС_РамаПоворотнаяЧастичнаяDAE_CQE_DKC:частичная 9U Ш=800мм:756167
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: частичная 9U Ш=800мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIEP9; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIEP9/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
