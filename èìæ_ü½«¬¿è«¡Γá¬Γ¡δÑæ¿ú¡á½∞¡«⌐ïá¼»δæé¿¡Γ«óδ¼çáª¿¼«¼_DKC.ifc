Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:29:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:29:34 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{C28B3DD6-2C74-49FA-B0C3-AEE49FB1BE13}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:29:34 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:29:34 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:29:34 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2362.027.003_10V–28V AC/DC_Ex ia IIC Ga U, КНС_БлокиКонтактныеСигнальнойЛампыСВинтовымЗажимом_DKC:2362.027.003_10V–28V AC/DC_Ex ia IIC Ga U:596802
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2362.027.003_10V–28V AC/DC_Ex ia IIC Ga U
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2362.027.003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для светофильтров для индикации работы цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • со светодиодом; • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2366.027.001_20V–250V AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеСигнальнойЛампыСВинтовымЗажимом_DKC:2366.027.001_20V–250V AC/DC_Ex d e IIC Gb:596807
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2366.027.001_20V–250V AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.027.001; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для светофильтров для индикации работы цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • со светодиодом; • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2366.027.002_380V–400V AC_Ex d e IIC Gb, КНС_БлокиКонтактныеСигнальнойЛампыСВинтовымЗажимом_DKC:2366.027.002_380V–400V AC_Ex d e IIC Gb:596808
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2366.027.002_380V–400V AC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.027.002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для светофильтров для индикации работы цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • со светодиодом; • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2366.027.003_10V–28V AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеСигнальнойЛампыСВинтовымЗажимом_DKC:2366.027.003_10V–28V AC/DC_Ex d e IIC Gb:596809
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2366.027.003_10V–28V AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.027.003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для светофильтров для индикации работы цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • со светодиодом; • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2366.027.004_50V–277 AC/DC_Ex d e IIC Gb, КНС_БлокиКонтактныеСигнальнойЛампыСВинтовымЗажимом_DKC:2366.027.004_50V–277 AC/DC_Ex d e IIC Gb:596810
In: Этаж 01
Type - Material: DKC_Стекло_Белое, DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2366.027.004_50V–277 AC/DC_Ex d e IIC Gb
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2366.027.004; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • контактный блок для светофильтров для индикации работы цепи; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • со светодиодом; • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; Комментарии к типоразмеру: Взрывозащищита элемент управления
