Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:06:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:06:40 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{6C224A0B-E1EC-4E01-A153-1D5CB09527C9}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:06:38 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:06:39 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:06:39 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: CAT5E_неэкранированная, КНС_ПатчПанель48Модулей_DKC:CAT5E_неэкранированная, 0 В, Однофазная Тип системы, 2 Провода:791879
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: CAT5E_неэкранированная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: RN5PPU242; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1394/RN5PPU242/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; Описание: Назначение • для экранированных и неэкранированных систем; • передача сигналов в структурированных кабельных системах. Типы панели • наборные панели на 48 модулей Keystone. Совместимость с компонентами • экранированные и неэкранированные pозеточные модули Keystone CAT 6А/6/5E. Отличительные особенности • нумерация портов и маркировочные поля; • встроенный организатор для кабелей; • облегченный алюминиевый корпус. Температурные диапазоны • хранение: от -40 до +70 °C; • эксплуатация: от -40 до +70 °C; • монтаж: от 0 до +70 °C. Упаковка • картонная коробка, 1 шт.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: CAT6_неэкранированная, КНС_ПатчПанель48Модулей_DKC:CAT6_неэкранированная, 0 В, Однофазная Тип системы, 2 Провода:791888
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: CAT6_неэкранированная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: RN6PPU242; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1394/RN6PPU242/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; Описание: Назначение • для экранированных и неэкранированных систем; • передача сигналов в структурированных кабельных системах. Типы панели • наборные панели на 48 модулей Keystone. Совместимость с компонентами • экранированные и неэкранированные pозеточные модули Keystone CAT 6А/6/5E. Отличительные особенности • нумерация портов и маркировочные поля; • встроенный организатор для кабелей; • облегченный алюминиевый корпус. Температурные диапазоны • хранение: от -40 до +70 °C; • эксплуатация: от -40 до +70 °C; • монтаж: от 0 до +70 °C. Упаковка • картонная коробка, 1 шт.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
