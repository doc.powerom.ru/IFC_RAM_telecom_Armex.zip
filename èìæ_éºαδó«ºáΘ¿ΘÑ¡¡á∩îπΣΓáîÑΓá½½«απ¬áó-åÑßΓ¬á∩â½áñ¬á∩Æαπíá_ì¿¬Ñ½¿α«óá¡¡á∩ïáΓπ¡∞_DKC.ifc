Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:50:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:50:18 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{2E69ABF7-B8D6-44F1-B5DF-D48A5113B175}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:50:17 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:50:18 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:50:18 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: металлорукав DN 10 - DN16 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 10 - DN16 жесткая труба:642136
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 10 - DN16 жесткая труба

# IfcFlowFitting: металлорукав DN 12 - DN16 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 12 - DN16 жесткая труба:642138
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 12 - DN16 жесткая труба

# IfcFlowFitting: металлорукав DN 15 - DN16 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 15 - DN16 жесткая труба:642140
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 15 - DN16 жесткая труба

# IfcFlowFitting: металлорукав DN 15 - DN20 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 15 - DN20 жесткая труба:642142
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 15 - DN20 жесткая труба

# IfcFlowFitting: металлорукав DN 20 - DN20 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 20 - DN20 жесткая труба:642144
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 20 - DN20 жесткая труба

# IfcFlowFitting: металлорукав DN 20 - DN25 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 20 - DN25 жесткая труба:642146
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 20 - DN25 жесткая труба

# IfcFlowFitting: металлорукав DN 26 - DN25 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 26 - DN25 жесткая труба:642148
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 26 - DN25 жесткая труба

# IfcFlowFitting: металлорукав DN 26 - DN32 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 26 - DN32 жесткая труба:642150
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 26 - DN32 жесткая труба

# IfcFlowFitting: металлорукав DN 35 - DN32 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 35 - DN32 жесткая труба:642152
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 35 - DN32 жесткая труба

# IfcFlowFitting: металлорукав DN 35 - DN40 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 35 - DN40 жесткая труба:642154
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 35 - DN40 жесткая труба

# IfcFlowFitting: металлорукав DN 40 - DN40 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 40 - DN40 жесткая труба:642159
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 40 - DN40 жесткая труба

# IfcFlowFitting: металлорукав DN 40 - DN50 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 40 - DN50 жесткая труба:642161
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 40 - DN50 жесткая труба

# IfcFlowFitting: металлорукав DN 50 - DN50 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 50 - DN50 жесткая труба:642163
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 50 - DN50 жесткая труба

# IfcFlowFitting: металлорукав DN 50 - DN63 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_НикелированнаяЛатунь_DKC:металлорукав DN 50 - DN63 жесткая труба:642754
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 50 - DN63 жесткая труба
