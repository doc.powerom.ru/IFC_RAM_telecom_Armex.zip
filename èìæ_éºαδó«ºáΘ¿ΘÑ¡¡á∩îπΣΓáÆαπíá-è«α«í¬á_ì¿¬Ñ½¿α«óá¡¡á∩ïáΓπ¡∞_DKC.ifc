Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:44:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:44:22 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{AF6D0892-5B1D-461A-9728-24FE3D639E09}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:44:21 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:44:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:44:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 16 - M16x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 16 - M16x1,5:626549
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 16 - M16x1,5

# IfcFlowFitting: DN 20 - M20x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 20 - M20x1,5:626551
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M20x1,5

# IfcFlowFitting: DN 25 - M25x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 25 - M25x1,5:626553
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 25 - M25x1,5

# IfcFlowFitting: DN 32 - M32x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 32 - M32x1,5:626555
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 32 - M32x1,5

# IfcFlowFitting: DN 40 - M40x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 40 - M40x1,5:626557
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M40x1,5

# IfcFlowFitting: DN 50 - M50x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 50 - M50x1,5:626559
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - M50x1,5

# IfcFlowFitting: DN 63 - M63x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_НикелированнаяЛатунь_DKC:DN 63 - M63x1,5:626561
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 63 - M63x1,5
