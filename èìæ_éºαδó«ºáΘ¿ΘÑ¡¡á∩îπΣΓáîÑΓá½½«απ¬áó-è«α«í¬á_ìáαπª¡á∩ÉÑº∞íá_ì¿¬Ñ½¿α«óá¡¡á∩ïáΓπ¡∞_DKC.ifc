Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:39:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:39:29 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B34A8632-5FB8-4AFE-B3FC-503EBCDF3970}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:39:28 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:39:28 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:39:28 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 10 - М16х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 10 - М16х1.5:621928
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10 - М16х1.5

# IfcFlowFitting: DN 12 - М16х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 12 - М16х1.5:621931
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - М16х1.5

# IfcFlowFitting: DN 15 - М16х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 15 - М16х1.5:621933
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - М16х1.5

# IfcFlowFitting: DN 15 - М20х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 15 - М20х1.5:621935
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - М20х1.5

# IfcFlowFitting: DN 20 - М20х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 20 - М20х1.5:621937
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - М20х1.5

# IfcFlowFitting: DN 20 - М25х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 20 - М25х1.5:621939
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - М25х1.5

# IfcFlowFitting: DN 26 - М25х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 26 - М25х1.5:621941
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - М25х1.5

# IfcFlowFitting: DN 26 - М32х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 26 - М32х1.5:621943
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - М32х1.5

# IfcFlowFitting: DN 35 - М40х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 35 - М40х1.5:621945
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 35 - М40х1.5

# IfcFlowFitting: DN 40 - М40х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 40 - М40х1.5:621947
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - М40х1.5

# IfcFlowFitting: DN 40 - М50х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 40 - М50х1.5:621969
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - М50х1.5

# IfcFlowFitting: DN 50 - М50х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 50 - М50х1.5:621971
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - М50х1.5

# IfcFlowFitting: DN 50 - М63х1.5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_НаружнаяРезьба_НикелированнаяЛатунь_DKC:DN 50 - М63х1.5:621973
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - М63х1.5
