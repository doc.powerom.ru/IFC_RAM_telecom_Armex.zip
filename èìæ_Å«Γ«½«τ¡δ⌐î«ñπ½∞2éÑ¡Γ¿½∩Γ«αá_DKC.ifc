Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:03:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:03:51 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F1F7D8D7-7BEB-4E1E-BAB6-F81B0860D6C5}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:03:50 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:03:50 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:03:51 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: RAL7035, КНС_ПотолочныйМодуль2Вентилятора_DKC:RAL7035, 0 В, Однофазная Тип системы, 2 Провода:775163
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5VSIT6002FG; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5VSIT6002FG/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • материал корпуса – стальной прокат толщиной 1,5 мм. Комплект поставки • шнур питания 1,8 м; • разъемы Schuko и C13; • крепеж (закладные гайки, шайбы и винты М6х16); Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: RAL9005, КНС_ПотолочныйМодуль2Вентилятора_DKC:RAL9005, 0 В, Однофазная Тип системы, 2 Провода:775284
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5VSIT6002FB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5VSIT6002FB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • материал корпуса – стальной прокат толщиной 1,5 мм. Комплект поставки • шнур питания 1,8 м; • разъемы Schuko и C13; • крепеж (закладные гайки, шайбы и винты М6х16); Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: С термостатом_RAL7035, КНС_ПотолочныйМодуль2Вентилятора_DKC:С термостатом_RAL7035, 0 В, Однофазная Тип системы, 2 Провода:776857
In: Этаж 01
Type - Material: DKC_Сталь_Светло-серый
Pset_BuildingElementProxyCommon - Reference: С термостатом_RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5VSIT6002FTG; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5VSIT6002FTG/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • материал корпуса – стальной прокат толщиной 1,5 мм. Комплект поставки • шнур питания 1,8 м; • разъемы Schuko и C13; • крепеж (закладные гайки, шайбы и винты М6х16); Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: С термостатом_RAL9005, КНС_ПотолочныйМодуль2Вентилятора_DKC:С термостатом_RAL9005, 0 В, Однофазная Тип системы, 2 Провода:776858
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: С термостатом_RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5VSIT6002FTB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5VSIT6002FTB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000331; Описание: Основные характеристики • материал корпуса – стальной прокат толщиной 1,5 мм. Комплект поставки • шнур питания 1,8 м; • разъемы Schuko и C13; • крепеж (закладные гайки, шайбы и винты М6х16); Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
