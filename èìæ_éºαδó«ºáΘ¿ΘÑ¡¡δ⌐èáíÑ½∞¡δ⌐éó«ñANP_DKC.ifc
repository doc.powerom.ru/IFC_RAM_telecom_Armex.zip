Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:37:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:37:37 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{595F1A82-EBF9-493F-891B-A66C4A6E5E89}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:37:35 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:37:35 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:37:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: M16х1,5 D5-10мм, Dn12мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M16х1,5 D5-10мм, Dn12мм_Нержавеющая сталь AISI316L:617028
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм, Dn12мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M16х1,5 D5-10мм, Dn12мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M16х1,5 D5-10мм, Dn12мм_Никелированная латунь:614803
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм, Dn12мм_Никелированная латунь

# IfcFlowFitting: M16х1,5 D5-10мм, Dn15мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M16х1,5 D5-10мм, Dn15мм_Нержавеющая сталь AISI316L:617030
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм, Dn15мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M16х1,5 D5-10мм, Dn15мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M16х1,5 D5-10мм, Dn15мм_Никелированная латунь:614805
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм, Dn15мм_Никелированная латунь

# IfcFlowFitting: M16х1,5 D5-7мм, Dn10мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M16х1,5 D5-7мм, Dn10мм_Нержавеющая сталь AISI316L:617026
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-7мм, Dn10мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M16х1,5 D5-7мм, Dn10мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M16х1,5 D5-7мм, Dn10мм_Никелированная латунь:614801
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-7мм, Dn10мм_Никелированная латунь

# IfcFlowFitting: M20х1,5 D5,5-13мм, Dn15мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M20х1,5 D5,5-13мм, Dn15мм_Нержавеющая сталь AISI316L:617032
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D5,5-13мм, Dn15мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M20х1,5 D5,5-13мм, Dn15мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M20х1,5 D5,5-13мм, Dn15мм_Никелированная латунь:614807
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D5,5-13мм, Dn15мм_Никелированная латунь

# IfcFlowFitting: M20х1,5 D8-13мм, Dn20мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M20х1,5 D8-13мм, Dn20мм_Нержавеющая сталь AISI316L:617034
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D8-13мм, Dn20мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M20х1,5 D8-13мм, Dn20мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M20х1,5 D8-13мм, Dn20мм_Никелированная латунь:614809
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D8-13мм, Dn20мм_Никелированная латунь

# IfcFlowFitting: M25х1,5 D10,5-18мм, Dn20мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M25х1,5 D10,5-18мм, Dn20мм_Нержавеющая сталь AISI316L:617036
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм, Dn20мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M25х1,5 D10,5-18мм, Dn20мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M25х1,5 D10,5-18мм, Dn20мм_Никелированная латунь:614811
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм, Dn20мм_Никелированная латунь

# IfcFlowFitting: M25х1,5 D10,5-18мм, Dn26мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M25х1,5 D10,5-18мм, Dn26мм_Нержавеющая сталь AISI316L:617038
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм, Dn26мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M25х1,5 D10,5-18мм, Dn26мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M25х1,5 D10,5-18мм, Dn26мм_Никелированная латунь:614813
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм, Dn26мм_Никелированная латунь

# IfcFlowFitting: M32х1,5 D15-24мм, Dn26мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M32х1,5 D15-24мм, Dn26мм_Нержавеющая сталь AISI316L:617040
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M32х1,5 D15-24мм, Dn26мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M32х1,5 D15-24мм, Dn26мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M32х1,5 D15-24мм, Dn26мм_Никелированная латунь:614815
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M32х1,5 D15-24мм, Dn26мм_Никелированная латунь

# IfcFlowFitting: M40х1,5 D21-30мм, Dn35мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M40х1,5 D21-30мм, Dn35мм_Нержавеющая сталь AISI316L:617042
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм, Dn35мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M40х1,5 D21-30мм, Dn35мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M40х1,5 D21-30мм, Dn35мм_Никелированная латунь:616578
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм, Dn35мм_Никелированная латунь

# IfcFlowFitting: M40х1,5 D21-30мм, Dn40мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M40х1,5 D21-30мм, Dn40мм_Нержавеющая сталь AISI316L:617044
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм, Dn40мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M40х1,5 D21-30мм, Dn40мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M40х1,5 D21-30мм, Dn40мм_Никелированная латунь:616580
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм, Dn40мм_Никелированная латунь

# IfcFlowFitting: M50х1,5 D24-33мм, Dn40мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M50х1,5 D24-33мм, Dn40мм_Нержавеющая сталь AISI316L:617046
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D24-33мм, Dn40мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M50х1,5 D24-33мм, Dn40мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M50х1,5 D24-33мм, Dn40мм_Никелированная латунь:616582
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D24-33мм, Dn40мм_Никелированная латунь

# IfcFlowFitting: M50х1,5 D27-36мм, Dn50мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M50х1,5 D27-36мм, Dn50мм_Нержавеющая сталь AISI316L:617048
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D27-36мм, Dn50мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M50х1,5 D27-36мм, Dn50мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M50х1,5 D27-36мм, Dn50мм_Никелированная латунь:616597
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D27-36мм, Dn50мм_Никелированная латунь

# IfcFlowFitting: M63х1,5 D36-45мм, Dn50мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M63х1,5 D36-45мм, Dn50мм_Нержавеющая сталь AISI316L:617050
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M63х1,5 D36-45мм, Dn50мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M63х1,5 D36-45мм, Dn50мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводANP_DKC:M63х1,5 D36-45мм, Dn50мм_Никелированная латунь:616599
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M63х1,5 D36-45мм, Dn50мм_Никелированная латунь
