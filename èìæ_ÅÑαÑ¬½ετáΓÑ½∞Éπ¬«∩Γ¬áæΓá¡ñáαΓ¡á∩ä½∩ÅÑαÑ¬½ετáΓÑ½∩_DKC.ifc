Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:15:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:15:11 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B3B9D521-F13E-4B60-ADAB-87063BBE2C0C}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:15:10 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:15:10 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:15:10 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2361.1804.622.04, КНС_ПереключательРукояткаСтандартнаяДляПереключателя_DKC:2361.1804.622.04:590371
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.1804.622.04
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.1804.622.04; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.1805.622.01, КНС_ПереключательРукояткаСтандартнаяДляПереключателя_DKC:2361.1805.622.01:590377
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.1805.622.01
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.1805.622.01; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.1806.622.04, КНС_ПереключательРукояткаСтандартнаяДляПереключателя_DKC:2361.1806.622.04:590378
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.1806.622.04
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.1806.622.04; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.1807.622.05, КНС_ПереключательРукояткаСтандартнаяДляПереключателя_DKC:2361.1807.622.05:590379
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.1807.622.05
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.1807.622.05; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления
