Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:10:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:10:28 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B13A3460-4A24-40B8-9AEB-E4C00883C1F8}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:10:27 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:10:28 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:10:28 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2361.0100.612.00_Черный, КНС_КнопкаОдинарнаяБезФиксацииСостояния_DKC:2361.0100.612.00_Черный:587526
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0100.612.00_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0100.612.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка на контактный блок для замыкания и размыкания электрических цепей управления без фиксации положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • комплектуется цветным колпачком с цветом согласно таблице; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0100.614.00_Красный, КНС_КнопкаОдинарнаяБезФиксацииСостояния_DKC:2361.0100.614.00_Красный:587724
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0100.614.00_Красный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0100.614.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка на контактный блок для замыкания и размыкания электрических цепей управления без фиксации положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • комплектуется цветным колпачком с цветом согласно таблице; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0100.615.00_Зеленый, КНС_КнопкаОдинарнаяБезФиксацииСостояния_DKC:2361.0100.615.00_Зеленый:587752
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0100.615.00_Зеленый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0100.615.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка на контактный блок для замыкания и размыкания электрических цепей управления без фиксации положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • комплектуется цветным колпачком с цветом согласно таблице; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0100.616.00_Желтый, КНС_КнопкаОдинарнаяБезФиксацииСостояния_DKC:2361.0100.616.00_Желтый:587755
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0100.616.00_Желтый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0100.616.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка на контактный блок для замыкания и размыкания электрических цепей управления без фиксации положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • комплектуется цветным колпачком с цветом согласно таблице; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0100.617.00_Синий, КНС_КнопкаОдинарнаяБезФиксацииСостояния_DKC:2361.0100.617.00_Синий:587758
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0100.617.00_Синий
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0100.617.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка на контактный блок для замыкания и размыкания электрических цепей управления без фиксации положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • комплектуется цветным колпачком с цветом согласно таблице; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0100.618.00_Белый, КНС_КнопкаОдинарнаяБезФиксацииСостояния_DKC:2361.0100.618.00_Белый:587761
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0100.618.00_Белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0100.618.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка на контактный блок для замыкания и размыкания электрических цепей управления без фиксации положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • комплектуется цветным колпачком с цветом согласно таблице; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления
