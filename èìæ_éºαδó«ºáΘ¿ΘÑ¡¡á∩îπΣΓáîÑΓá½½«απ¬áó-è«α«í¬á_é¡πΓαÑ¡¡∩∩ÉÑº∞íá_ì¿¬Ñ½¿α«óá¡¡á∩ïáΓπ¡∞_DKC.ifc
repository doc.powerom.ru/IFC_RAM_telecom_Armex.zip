Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:43:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:43:26 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{8FA1EB37-6E50-419E-BEAA-6602490A3D41}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:43:25 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:43:25 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:43:25 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 10 - M16x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 10 - M16x1,5:625813
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 10 - M16x1,5

# IfcFlowFitting: DN 12 - M16x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 12 - M16x1,5:625815
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 12 - M16x1,5

# IfcFlowFitting: DN 15 - M16x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 15 - M16x1,5:625817
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - M16x1,5

# IfcFlowFitting: DN 15 - M20x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 15 - M20x1,5:625819
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 15 - M20x1,5

# IfcFlowFitting: DN 20 - M20x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 20 - M20x1,5:625821
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M20x1,5

# IfcFlowFitting: DN 20 - M25x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 20 - M25x1,5:625823
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M25x1,5

# IfcFlowFitting: DN 26 - M25x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 26 - M25x1,5:625825
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - M25x1,5

# IfcFlowFitting: DN 26 - M32x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 26 - M32x1,5:625827
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 26 - M32x1,5

# IfcFlowFitting: DN 35 - M32x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 35 - M32x1,5:626143
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 35 - M32x1,5

# IfcFlowFitting: DN 35 - M40x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 35 - M40x1,5:625829
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 35 - M40x1,5

# IfcFlowFitting: DN 40 - M40x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 40 - M40x1,5:625831
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M40x1,5

# IfcFlowFitting: DN 40 - M50x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 40 - M50x1,5:625834
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M50x1,5

# IfcFlowFitting: DN 50 - M50x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 50 - M50x1,5:625836
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - M50x1,5

# IfcFlowFitting: DN 50 - M63x1,5, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 50 - M63x1,5:625838
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - M63x1,5
