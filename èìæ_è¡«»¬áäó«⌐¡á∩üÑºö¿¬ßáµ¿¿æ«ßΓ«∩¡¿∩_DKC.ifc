Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:10:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:10:50 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{364B0C6C-0A78-4FF8-8750-A5F6D2F83D29}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:10:49 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:10:50 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:10:50 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Без фиксации состояния, КНС_КнопкаДвойнаяБезФиксацииСостояния_DKC:Без фиксации состояния:578392
In: Этаж 01
Type - Material: DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: Без фиксации состояния
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0100.610.00; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая двойная насадка на контактный блок для замыкания и размыкания электрических цепей управления без фиксации положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • комплектуется цветными колпачками с цветом согласно таблицы; • не комплектуется контактным блоком.; Комментарии к типоразмеру: Взрывозащищита элемент управления
