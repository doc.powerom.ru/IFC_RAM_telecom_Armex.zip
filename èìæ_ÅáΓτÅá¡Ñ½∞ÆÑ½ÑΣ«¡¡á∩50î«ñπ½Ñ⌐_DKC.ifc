Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T23:52:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 23:52:16 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{92210DFC-67DB-421D-BA2D-E7DF5CDB859E}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 23:52:15 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 23:52:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 23:52:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: CAT 3, КНС_ПатчПанельТелефонная50Модулей_DKC:CAT 3, 0 В, Однофазная Тип системы, 2 Провода:801341
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: CAT 3
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: RN3PP501BK; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/1394/RN3PP501BK/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; Описание: Назначение • для экранированных систем; • передача сигналов в структурированных кабельных системах. Типы панели • экранированная панель 24 порта; • моноблочная конструкция. Совместимость с компонентами • экранированные кабели CAT 6A. Отличительные особенности • допустимый диаметр медных проводников 0,4-0,64 мм (22-26 AWG); • поддерживает технологию HDBaseT; • разъемы 8P8C (RJ45) никелированные, с позолоченными контактами (покрытие 0,75 µм); • ресурс подключений/отключений (min) – 750 циклов; • встроенный организатор для кабелей; • облегченный алюминиевый корпус. Температурные диапазоны • хранение: от -40 до +70 °C; • эксплуатация: от -40 до +70 °C; • монтаж: от 0 до +70 °C Упаковка • картонная коробка, 1 шт.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
