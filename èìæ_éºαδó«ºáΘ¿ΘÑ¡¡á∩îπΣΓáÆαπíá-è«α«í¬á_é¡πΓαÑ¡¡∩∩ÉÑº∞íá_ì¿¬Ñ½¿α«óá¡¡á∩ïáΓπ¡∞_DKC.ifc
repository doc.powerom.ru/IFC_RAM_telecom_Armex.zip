Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:47:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:47:42 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{12E23A32-CDEA-4F83-B73B-73BDA48F86D8}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:47:41 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:47:42 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:47:42 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: DN 16 - M16x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 16 - M16x1,5:632206
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 16 - M16x1,5

# IfcFlowFitting: DN 20 - M20x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 20 - M20x1,5:632208
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 20 - M20x1,5

# IfcFlowFitting: DN 25 - M25x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 25 - M25x1,5:632210
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 25 - M25x1,5

# IfcFlowFitting: DN 32 - M32x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 32 - M32x1,5:632212
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 32 - M32x1,5

# IfcFlowFitting: DN 40 - M40x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 40 - M40x1,5:632214
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 40 - M40x1,5

# IfcFlowFitting: DN 50 - M50x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 50 - M50x1,5:632216
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 50 - M50x1,5

# IfcFlowFitting: DN 63- M63x1,5, КНС_ВзрывозащищеннаяМуфтаТруба-Коробка_ВнутренняяРезьба_НикелированнаяЛатунь_DKC:DN 63- M63x1,5:632218
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: DN 63- M63x1,5
