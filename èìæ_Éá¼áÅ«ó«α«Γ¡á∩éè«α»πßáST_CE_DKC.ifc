Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:54:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:54:14 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{60341AD2-5587-493C-8221-B7177487F744}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:54:12 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:54:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:54:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 12U 600мм Ш=600мм, КНС_РамаПоворотнаяВКорпусаST_CE_DKC:12U 600мм Ш=600мм:754075
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 12U 600мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIE860; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIE860/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 15U 600мм Ш=600мм, КНС_РамаПоворотнаяВКорпусаST_CE_DKC:15U 600мм Ш=600мм:753770
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 15U 600мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIE861; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIE861/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 3U 400мм Ш=600мм, КНС_РамаПоворотнаяВКорпусаST_CE_DKC:3U 400мм Ш=600мм:752900
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 3U 400мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIE460; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIE460/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 6U 400мм Ш=600мм, КНС_РамаПоворотнаяВКорпусаST_CE_DKC:6U 400мм Ш=600мм:753754
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 6U 400мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIE461; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIE461/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 9U 600мм Ш=600мм, КНС_РамаПоворотнаяВКорпусаST_CE_DKC:9U 600мм Ш=600мм:753767
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 9U 600мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5TIE660; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5TIE660/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcOpeningElement: Opening (384)
In: Этаж 01
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Name (КНС_РамаПоворотнаяВКорпусаST_CE_DKC:...)
3U 400мм Ш=600мм:752900:1
3U 400мм Ш=600мм:752900:2
3U 400мм Ш=600мм:752900:3
3U 400мм Ш=600мм:752900:4
3U 400мм Ш=600мм:752900:5
3U 400мм Ш=600мм:752900:6
3U 400мм Ш=600мм:752900:7
3U 400мм Ш=600мм:752900:8
3U 400мм Ш=600мм:752900:9
3U 400мм Ш=600мм:752900:10
3U 400мм Ш=600мм:752900:11
3U 400мм Ш=600мм:752900:12
3U 400мм Ш=600мм:752900:13
3U 400мм Ш=600мм:752900:14
3U 400мм Ш=600мм:752900:15
3U 400мм Ш=600мм:752900:16
3U 400мм Ш=600мм:752900:17
3U 400мм Ш=600мм:752900:18
3U 400мм Ш=600мм:752900:19
3U 400мм Ш=600мм:752900:20
3U 400мм Ш=600мм:752900:21
3U 400мм Ш=600мм:752900:22
3U 400мм Ш=600мм:752900:23
3U 400мм Ш=600мм:752900:24
3U 400мм Ш=600мм:752900:25
3U 400мм Ш=600мм:752900:26
3U 400мм Ш=600мм:752900:27
3U 400мм Ш=600мм:752900:28
3U 400мм Ш=600мм:752900:29
3U 400мм Ш=600мм:752900:30
3U 400мм Ш=600мм:752900:31
3U 400мм Ш=600мм:752900:32
3U 400мм Ш=600мм:752900:33
3U 400мм Ш=600мм:752900:34
3U 400мм Ш=600мм:752900:35
3U 400мм Ш=600мм:752900:36
3U 400мм Ш=600мм:752900:37
3U 400мм Ш=600мм:752900:38
3U 400мм Ш=600мм:752900:39
3U 400мм Ш=600мм:752900:40
3U 400мм Ш=600мм:752900:41
3U 400мм Ш=600мм:752900:42
3U 400мм Ш=600мм:752900:43
3U 400мм Ш=600мм:752900:44
3U 400мм Ш=600мм:752900:45
3U 400мм Ш=600мм:752900:46
3U 400мм Ш=600мм:752900:47
3U 400мм Ш=600мм:752900:48
6U 400мм Ш=600мм:753754:1
6U 400мм Ш=600мм:753754:2
6U 400мм Ш=600мм:753754:3
6U 400мм Ш=600мм:753754:4
6U 400мм Ш=600мм:753754:5
6U 400мм Ш=600мм:753754:6
6U 400мм Ш=600мм:753754:7
6U 400мм Ш=600мм:753754:8
6U 400мм Ш=600мм:753754:9
6U 400мм Ш=600мм:753754:10
6U 400мм Ш=600мм:753754:11
6U 400мм Ш=600мм:753754:12
6U 400мм Ш=600мм:753754:13
6U 400мм Ш=600мм:753754:14
6U 400мм Ш=600мм:753754:15
6U 400мм Ш=600мм:753754:16
6U 400мм Ш=600мм:753754:17
6U 400мм Ш=600мм:753754:18
6U 400мм Ш=600мм:753754:19
6U 400мм Ш=600мм:753754:20
6U 400мм Ш=600мм:753754:21
6U 400мм Ш=600мм:753754:22
6U 400мм Ш=600мм:753754:23
6U 400мм Ш=600мм:753754:24
6U 400мм Ш=600мм:753754:25
6U 400мм Ш=600мм:753754:26
6U 400мм Ш=600мм:753754:27
6U 400мм Ш=600мм:753754:28
6U 400мм Ш=600мм:753754:29
6U 400мм Ш=600мм:753754:30
6U 400мм Ш=600мм:753754:31
6U 400мм Ш=600мм:753754:32
6U 400мм Ш=600мм:753754:33
6U 400мм Ш=600мм:753754:34
6U 400мм Ш=600мм:753754:35
6U 400мм Ш=600мм:753754:36
6U 400мм Ш=600мм:753754:37
6U 400мм Ш=600мм:753754:38
6U 400мм Ш=600мм:753754:39
6U 400мм Ш=600мм:753754:40
6U 400мм Ш=600мм:753754:41
6U 400мм Ш=600мм:753754:42
6U 400мм Ш=600мм:753754:43
6U 400мм Ш=600мм:753754:44
6U 400мм Ш=600мм:753754:45
6U 400мм Ш=600мм:753754:46
6U 400мм Ш=600мм:753754:47
6U 400мм Ш=600мм:753754:48
9U 600мм Ш=600мм:753767:1
9U 600мм Ш=600мм:753767:2
9U 600мм Ш=600мм:753767:3
9U 600мм Ш=600мм:753767:4
9U 600мм Ш=600мм:753767:5
9U 600мм Ш=600мм:753767:6
9U 600мм Ш=600мм:753767:7
9U 600мм Ш=600мм:753767:8
9U 600мм Ш=600мм:753767:9
9U 600мм Ш=600мм:753767:10
9U 600мм Ш=600мм:753767:11
9U 600мм Ш=600мм:753767:12
9U 600мм Ш=600мм:753767:13
9U 600мм Ш=600мм:753767:14
9U 600мм Ш=600мм:753767:15
9U 600мм Ш=600мм:753767:16
9U 600мм Ш=600мм:753767:17
9U 600мм Ш=600мм:753767:18
9U 600мм Ш=600мм:753767:19
9U 600мм Ш=600мм:753767:20
9U 600мм Ш=600мм:753767:21
9U 600мм Ш=600мм:753767:22
9U 600мм Ш=600мм:753767:23
9U 600мм Ш=600мм:753767:24
9U 600мм Ш=600мм:753767:25
9U 600мм Ш=600мм:753767:26
9U 600мм Ш=600мм:753767:27
9U 600мм Ш=600мм:753767:28
9U 600мм Ш=600мм:753767:29
9U 600мм Ш=600мм:753767:30
9U 600мм Ш=600мм:753767:31
9U 600мм Ш=600мм:753767:32
9U 600мм Ш=600мм:753767:33
9U 600мм Ш=600мм:753767:34
9U 600мм Ш=600мм:753767:35
9U 600мм Ш=600мм:753767:36
9U 600мм Ш=600мм:753767:37
9U 600мм Ш=600мм:753767:38
9U 600мм Ш=600мм:753767:39
9U 600мм Ш=600мм:753767:40
9U 600мм Ш=600мм:753767:41
9U 600мм Ш=600мм:753767:42
9U 600мм Ш=600мм:753767:43
9U 600мм Ш=600мм:753767:44
9U 600мм Ш=600мм:753767:45
9U 600мм Ш=600мм:753767:46
9U 600мм Ш=600мм:753767:47
9U 600мм Ш=600мм:753767:48
9U 600мм Ш=600мм:753767:49
9U 600мм Ш=600мм:753767:50
9U 600мм Ш=600мм:753767:51
9U 600мм Ш=600мм:753767:52
9U 600мм Ш=600мм:753767:53
9U 600мм Ш=600мм:753767:54
9U 600мм Ш=600мм:753767:55
9U 600мм Ш=600мм:753767:56
9U 600мм Ш=600мм:753767:57
9U 600мм Ш=600мм:753767:58
9U 600мм Ш=600мм:753767:59
9U 600мм Ш=600мм:753767:60
9U 600мм Ш=600мм:753767:61
9U 600мм Ш=600мм:753767:62
9U 600мм Ш=600мм:753767:63
9U 600мм Ш=600мм:753767:64
9U 600мм Ш=600мм:753767:65
9U 600мм Ш=600мм:753767:66
9U 600мм Ш=600мм:753767:67
9U 600мм Ш=600мм:753767:68
9U 600мм Ш=600мм:753767:69
9U 600мм Ш=600мм:753767:70
9U 600мм Ш=600мм:753767:71
9U 600мм Ш=600мм:753767:72
15U 600мм Ш=600мм:753770:1
15U 600мм Ш=600мм:753770:2
15U 600мм Ш=600мм:753770:3
15U 600мм Ш=600мм:753770:4
15U 600мм Ш=600мм:753770:5
15U 600мм Ш=600мм:753770:6
15U 600мм Ш=600мм:753770:7
15U 600мм Ш=600мм:753770:8
15U 600мм Ш=600мм:753770:9
15U 600мм Ш=600мм:753770:10
15U 600мм Ш=600мм:753770:11
15U 600мм Ш=600мм:753770:12
15U 600мм Ш=600мм:753770:13
15U 600мм Ш=600мм:753770:14
15U 600мм Ш=600мм:753770:15
15U 600мм Ш=600мм:753770:16
15U 600мм Ш=600мм:753770:17
15U 600мм Ш=600мм:753770:18
15U 600мм Ш=600мм:753770:19
15U 600мм Ш=600мм:753770:20
15U 600мм Ш=600мм:753770:21
15U 600мм Ш=600мм:753770:22
15U 600мм Ш=600мм:753770:23
15U 600мм Ш=600мм:753770:24
15U 600мм Ш=600мм:753770:25
15U 600мм Ш=600мм:753770:26
15U 600мм Ш=600мм:753770:27
15U 600мм Ш=600мм:753770:28
15U 600мм Ш=600мм:753770:29
15U 600мм Ш=600мм:753770:30
15U 600мм Ш=600мм:753770:31
15U 600мм Ш=600мм:753770:32
15U 600мм Ш=600мм:753770:33
15U 600мм Ш=600мм:753770:34
15U 600мм Ш=600мм:753770:35
15U 600мм Ш=600мм:753770:36
15U 600мм Ш=600мм:753770:37
15U 600мм Ш=600мм:753770:38
15U 600мм Ш=600мм:753770:39
15U 600мм Ш=600мм:753770:40
15U 600мм Ш=600мм:753770:41
15U 600мм Ш=600мм:753770:42
15U 600мм Ш=600мм:753770:43
15U 600мм Ш=600мм:753770:44
15U 600мм Ш=600мм:753770:45
15U 600мм Ш=600мм:753770:46
15U 600мм Ш=600мм:753770:47
15U 600мм Ш=600мм:753770:48
15U 600мм Ш=600мм:753770:49
15U 600мм Ш=600мм:753770:50
15U 600мм Ш=600мм:753770:51
15U 600мм Ш=600мм:753770:52
15U 600мм Ш=600мм:753770:53
15U 600мм Ш=600мм:753770:54
15U 600мм Ш=600мм:753770:55
15U 600мм Ш=600мм:753770:56
15U 600мм Ш=600мм:753770:57
15U 600мм Ш=600мм:753770:58
15U 600мм Ш=600мм:753770:59
15U 600мм Ш=600мм:753770:60
15U 600мм Ш=600мм:753770:61
15U 600мм Ш=600мм:753770:62
15U 600мм Ш=600мм:753770:63
15U 600мм Ш=600мм:753770:64
15U 600мм Ш=600мм:753770:65
15U 600мм Ш=600мм:753770:66
15U 600мм Ш=600мм:753770:67
15U 600мм Ш=600мм:753770:68
15U 600мм Ш=600мм:753770:69
15U 600мм Ш=600мм:753770:70
15U 600мм Ш=600мм:753770:71
15U 600мм Ш=600мм:753770:72
15U 600мм Ш=600мм:753770:73
15U 600мм Ш=600мм:753770:74
15U 600мм Ш=600мм:753770:75
15U 600мм Ш=600мм:753770:76
15U 600мм Ш=600мм:753770:77
15U 600мм Ш=600мм:753770:78
15U 600мм Ш=600мм:753770:79
15U 600мм Ш=600мм:753770:80
15U 600мм Ш=600мм:753770:81
15U 600мм Ш=600мм:753770:82
15U 600мм Ш=600мм:753770:83
15U 600мм Ш=600мм:753770:84
15U 600мм Ш=600мм:753770:85
15U 600мм Ш=600мм:753770:86
15U 600мм Ш=600мм:753770:87
15U 600мм Ш=600мм:753770:88
15U 600мм Ш=600мм:753770:89
15U 600мм Ш=600мм:753770:90
15U 600мм Ш=600мм:753770:91
15U 600мм Ш=600мм:753770:92
15U 600мм Ш=600мм:753770:93
15U 600мм Ш=600мм:753770:94
15U 600мм Ш=600мм:753770:95
15U 600мм Ш=600мм:753770:96
15U 600мм Ш=600мм:753770:97
15U 600мм Ш=600мм:753770:98
15U 600мм Ш=600мм:753770:99
15U 600мм Ш=600мм:753770:100
15U 600мм Ш=600мм:753770:101
15U 600мм Ш=600мм:753770:102
15U 600мм Ш=600мм:753770:103
15U 600мм Ш=600мм:753770:104
15U 600мм Ш=600мм:753770:105
15U 600мм Ш=600мм:753770:106
15U 600мм Ш=600мм:753770:107
15U 600мм Ш=600мм:753770:108
15U 600мм Ш=600мм:753770:109
15U 600мм Ш=600мм:753770:110
15U 600мм Ш=600мм:753770:111
15U 600мм Ш=600мм:753770:112
15U 600мм Ш=600мм:753770:113
15U 600мм Ш=600мм:753770:114
15U 600мм Ш=600мм:753770:115
15U 600мм Ш=600мм:753770:116
15U 600мм Ш=600мм:753770:117
15U 600мм Ш=600мм:753770:118
15U 600мм Ш=600мм:753770:119
15U 600мм Ш=600мм:753770:120
12U 600мм Ш=600мм:754075:1
12U 600мм Ш=600мм:754075:2
12U 600мм Ш=600мм:754075:3
12U 600мм Ш=600мм:754075:4
12U 600мм Ш=600мм:754075:5
12U 600мм Ш=600мм:754075:6
12U 600мм Ш=600мм:754075:7
12U 600мм Ш=600мм:754075:8
12U 600мм Ш=600мм:754075:9
12U 600мм Ш=600мм:754075:10
12U 600мм Ш=600мм:754075:11
12U 600мм Ш=600мм:754075:12
12U 600мм Ш=600мм:754075:13
12U 600мм Ш=600мм:754075:14
12U 600мм Ш=600мм:754075:15
12U 600мм Ш=600мм:754075:16
12U 600мм Ш=600мм:754075:17
12U 600мм Ш=600мм:754075:18
12U 600мм Ш=600мм:754075:19
12U 600мм Ш=600мм:754075:20
12U 600мм Ш=600мм:754075:21
12U 600мм Ш=600мм:754075:22
12U 600мм Ш=600мм:754075:23
12U 600мм Ш=600мм:754075:24
12U 600мм Ш=600мм:754075:25
12U 600мм Ш=600мм:754075:26
12U 600мм Ш=600мм:754075:27
12U 600мм Ш=600мм:754075:28
12U 600мм Ш=600мм:754075:29
12U 600мм Ш=600мм:754075:30
12U 600мм Ш=600мм:754075:31
12U 600мм Ш=600мм:754075:32
12U 600мм Ш=600мм:754075:33
12U 600мм Ш=600мм:754075:34
12U 600мм Ш=600мм:754075:35
12U 600мм Ш=600мм:754075:36
12U 600мм Ш=600мм:754075:37
12U 600мм Ш=600мм:754075:38
12U 600мм Ш=600мм:754075:39
12U 600мм Ш=600мм:754075:40
12U 600мм Ш=600мм:754075:41
12U 600мм Ш=600мм:754075:42
12U 600мм Ш=600мм:754075:43
12U 600мм Ш=600мм:754075:44
12U 600мм Ш=600мм:754075:45
12U 600мм Ш=600мм:754075:46
12U 600мм Ш=600мм:754075:47
12U 600мм Ш=600мм:754075:48
12U 600мм Ш=600мм:754075:49
12U 600мм Ш=600мм:754075:50
12U 600мм Ш=600мм:754075:51
12U 600мм Ш=600мм:754075:52
12U 600мм Ш=600мм:754075:53
12U 600мм Ш=600мм:754075:54
12U 600мм Ш=600мм:754075:55
12U 600мм Ш=600мм:754075:56
12U 600мм Ш=600мм:754075:57
12U 600мм Ш=600мм:754075:58
12U 600мм Ш=600мм:754075:59
12U 600мм Ш=600мм:754075:60
12U 600мм Ш=600мм:754075:61
12U 600мм Ш=600мм:754075:62
12U 600мм Ш=600мм:754075:63
12U 600мм Ш=600мм:754075:64
12U 600мм Ш=600мм:754075:65
12U 600мм Ш=600мм:754075:66
12U 600мм Ш=600мм:754075:67
12U 600мм Ш=600мм:754075:68
12U 600мм Ш=600мм:754075:69
12U 600мм Ш=600мм:754075:70
12U 600мм Ш=600мм:754075:71
12U 600мм Ш=600мм:754075:72
12U 600мм Ш=600мм:754075:73
12U 600мм Ш=600мм:754075:74
12U 600мм Ш=600мм:754075:75
12U 600мм Ш=600мм:754075:76
12U 600мм Ш=600мм:754075:77
12U 600мм Ш=600мм:754075:78
12U 600мм Ш=600мм:754075:79
12U 600мм Ш=600мм:754075:80
12U 600мм Ш=600мм:754075:81
12U 600мм Ш=600мм:754075:82
12U 600мм Ш=600мм:754075:83
12U 600мм Ш=600мм:754075:84
12U 600мм Ш=600мм:754075:85
12U 600мм Ш=600мм:754075:86
12U 600мм Ш=600мм:754075:87
12U 600мм Ш=600мм:754075:88
12U 600мм Ш=600мм:754075:89
12U 600мм Ш=600мм:754075:90
12U 600мм Ш=600мм:754075:91
12U 600мм Ш=600мм:754075:92
12U 600мм Ш=600мм:754075:93
12U 600мм Ш=600мм:754075:94
12U 600мм Ш=600мм:754075:95
12U 600мм Ш=600мм:754075:96
