Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:03:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:03:17 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{3DDFA010-D522-4688-BB33-AAC603B3BEB9}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:03:17 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:03:17 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:03:17 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 40х40, КНС_ДержательКабеляCL_DKC:40х40:785712
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 40х40
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: R5CMDIT3HEB; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5ITCL4040/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000322; Описание: Основные характеристики • изготовлены из пластика, не повреждают оболочки кабелей; • комплект поставки - 6 колец и 6 наборов крепежа; • монтаж с помощью стандартного набора винт-шайба-гайка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 40х60, КНС_ДержательКабеляCL_DKC:40х60:785713
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 40х60
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: R5ITCL4060; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5ITCL4060/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000322; Описание: Основные характеристики • изготовлены из пластика, не повреждают оболочки кабелей; • комплект поставки - 6 колец и 6 наборов крепежа; • монтаж с помощью стандартного набора винт-шайба-гайка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары

# IfcBuildingElementProxy: 60х60, КНС_ДержательКабеляCL_DKC:60х60:785768
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 60х60
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: упаковка; ADSK_Код изделия: R5ITCL6060; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5ITCL6060/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC000322; Описание: Основные характеристики • изготовлены из пластика, не повреждают оболочки кабелей; • комплект поставки - 6 колец и 6 наборов крепежа; • монтаж с помощью стандартного набора винт-шайба-гайка.; Комментарии к типоразмеру: RAM telecom – 19" аксессуары
