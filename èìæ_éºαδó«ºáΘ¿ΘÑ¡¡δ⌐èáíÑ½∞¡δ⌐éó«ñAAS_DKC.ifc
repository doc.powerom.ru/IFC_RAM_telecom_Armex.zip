Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:31:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:31:40 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{40A530C6-32A7-48A9-9009-29E77DFFEF6F}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:31:38 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:31:38 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:31:38 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: M16х1,5 D5-10мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M16х1,5 D5-10мм_Нержавеющая сталь AISI316L:608069
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M16х1,5 D5-10мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M16х1,5 D5-10мм_Никелированная латунь:564045
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M16х1,5 D5-10мм_Никелированная латунь

# IfcFlowFitting: M20х1,5 D5,5-13мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M20х1,5 D5,5-13мм_Нержавеющая сталь AISI316L:608071
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D5,5-13мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M20х1,5 D5,5-13мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M20х1,5 D5,5-13мм_Никелированная латунь:564392
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M20х1,5 D5,5-13мм_Никелированная латунь

# IfcFlowFitting: M25х1,5 D10,5-18мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M25х1,5 D10,5-18мм_Нержавеющая сталь AISI316L:608073
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M25х1,5 D10,5-18мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M25х1,5 D10,5-18мм_Никелированная латунь:564415
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M25х1,5 D10,5-18мм_Никелированная латунь

# IfcFlowFitting: M32х1,5 D15-24мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M32х1,5 D15-24мм_Нержавеющая сталь AISI316L:608075
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M32х1,5 D15-24мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M32х1,5 D15-24мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M32х1,5 D15-24мм_Никелированная латунь:564421
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M32х1,5 D15-24мм_Никелированная латунь

# IfcFlowFitting: M40х1,5 D21-30мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M40х1,5 D21-30мм_Нержавеющая сталь AISI316L:608077
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M40х1,5 D21-30мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M40х1,5 D21-30мм_Никелированная латунь:564427
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M40х1,5 D21-30мм_Никелированная латунь

# IfcFlowFitting: M50х1,5 D24-36мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M50х1,5 D24-36мм_Нержавеющая сталь AISI316L:608079
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D24-36мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M50х1,5 D24-36мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M50х1,5 D24-36мм_Никелированная латунь:564433
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M50х1,5 D24-36мм_Никелированная латунь

# IfcFlowFitting: M63х1,5 D36-45мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M63х1,5 D36-45мм_Нержавеющая сталь AISI316L:608081
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M63х1,5 D36-45мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M63х1,5 D36-45мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M63х1,5 D36-45мм_Никелированная латунь:564439
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M63х1,5 D36-45мм_Никелированная латунь

# IfcFlowFitting: M75х1,5 D45-54мм_Нержавеющая сталь AISI316L, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M75х1,5 D45-54мм_Нержавеющая сталь AISI316L:608083
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M75х1,5 D45-54мм_Нержавеющая сталь AISI316L

# IfcFlowFitting: M75х1,5 D45-54мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M75х1,5 D45-54мм_Никелированная латунь:564445
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M75х1,5 D45-54мм_Никелированная латунь

# IfcFlowFitting: M90х2 D54-62мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M90х2 D54-62мм_Никелированная латунь:564656
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M90х2 D54-62мм_Никелированная латунь

# IfcFlowFitting: M90х2 D62-68мм_Никелированная латунь, КНС_ВзрывозащищенныйКабельныйВводAAS_DKC:M90х2 D62-68мм_Никелированная латунь:564667
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: M90х2 D62-68мм_Никелированная латунь
