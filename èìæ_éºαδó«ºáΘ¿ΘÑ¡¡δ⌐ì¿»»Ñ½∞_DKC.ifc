Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:59:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:59:00 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{5BE594B4-E64D-4EBD-9150-7EECB29ECCD4}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:59:00 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:59:00 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:59:00 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: М16х1,5, КНС_ВзрывозащищенныйНиппель_DKC:М16х1,5:648111
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М16х1,5

# IfcFlowFitting: М20х1,5, КНС_ВзрывозащищенныйНиппель_DKC:М20х1,5:648113
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М20х1,5

# IfcFlowFitting: М25х1,5, КНС_ВзрывозащищенныйНиппель_DKC:М25х1,5:648115
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М25х1,5

# IfcFlowFitting: М32х1,5, КНС_ВзрывозащищенныйНиппель_DKC:М32х1,5:648117
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М32х1,5

# IfcFlowFitting: М40х1,5, КНС_ВзрывозащищенныйНиппель_DKC:М40х1,5:648119
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М40х1,5

# IfcFlowFitting: М50х1,5, КНС_ВзрывозащищенныйНиппель_DKC:М50х1,5:648121
In: Этаж 01
Type - Material: DKC_Латунь_Никелированная_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: М50х1,5
