Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:50:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:50:47 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{786B19DC-8834-4081-9C2A-C57F35256BF7}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:50:46 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:50:47 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:50:47 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: металлорукав DN 15 - DN20 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:металлорукав DN 15 - DN20 жесткая труба:642835
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 15 - DN20 жесткая труба

# IfcFlowFitting: металлорукав DN 20 - DN25 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:металлорукав DN 20 - DN25 жесткая труба:642839
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 20 - DN25 жесткая труба

# IfcFlowFitting: металлорукав DN 26 - DN32 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:металлорукав DN 26 - DN32 жесткая труба:642843
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 26 - DN32 жесткая труба

# IfcFlowFitting: металлорукав DN 35 - DN40 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:металлорукав DN 35 - DN40 жесткая труба:642847
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 35 - DN40 жесткая труба

# IfcFlowFitting: металлорукав DN 40 - DN50 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:металлорукав DN 40 - DN50 жесткая труба:642851
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 40 - DN50 жесткая труба

# IfcFlowFitting: металлорукав DN 50 - DN63 жесткая труба, КНС_ВзрывозащищеннаяМуфтаМеталлорукав-ЖесткаяГладкаяТруба_AISI316L_DKC:металлорукав DN 50 - DN63 жесткая труба:642855
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_AISI 316L_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: металлорукав DN 50 - DN63 жесткая труба
