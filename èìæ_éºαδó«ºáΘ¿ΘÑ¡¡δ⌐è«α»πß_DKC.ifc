Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:59:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:59:57 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F8673E6A-723D-4A6B-99B0-3A7BEA72DC0F}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:59:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:59:56 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:59:56 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowFitting: 100х100х80 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:100х100х80 мм_коррозионностойкий алюминий:580478
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 100х100х80 мм_коррозионностойкий алюминий

# IfcFlowFitting: 110х75х56 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:110х75х56 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601269
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 110х75х56 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 120х120х90 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:120х120х90 мм_коррозионностойкий алюминий:580496
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 120х120х90 мм_коррозионностойкий алюминий

# IfcFlowFitting: 120х120х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:120х120х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601270
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 120х120х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 125х80х57 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:125х80х57 мм_коррозионностойкий алюминий:580501
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 125х80х57 мм_коррозионностойкий алюминий

# IfcFlowFitting: 140х140х90 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:140х140х90 мм_коррозионностойкий алюминий:580506
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 140х140х90 мм_коррозионностойкий алюминий

# IfcFlowFitting: 160х160х90 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:160х160х90 мм_коррозионностойкий алюминий:580511
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 160х160х90 мм_коррозионностойкий алюминий

# IfcFlowFitting: 160х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:160х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601271
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 160х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 180х180х100 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:180х180х100 мм_коррозионностойкий алюминий:580516
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 180х180х100 мм_коррозионностойкий алюминий

# IfcFlowFitting: 200х140х90 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:200х140х90 мм_коррозионностойкий алюминий:580521
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 200х140х90 мм_коррозионностойкий алюминий

# IfcFlowFitting: 220х120х90 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:220х120х90 мм_коррозионностойкий алюминий:580526
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 220х120х90 мм_коррозионностойкий алюминий

# IfcFlowFitting: 220х120х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:220х120х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601272
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 220х120х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 230х200х110 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:230х200х110 мм_коррозионностойкий алюминий:580531
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 230х200х110 мм_коррозионностойкий алюминий

# IfcFlowFitting: 230х200х180 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:230х200х180 мм_коррозионностойкий алюминий:580536
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 230х200х180 мм_коррозионностойкий алюминий

# IfcFlowFitting: 250х250х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:250х250х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601273
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 250х250х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 260х160х90 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:260х160х90 мм_коррозионностойкий алюминий:580541
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 260х160х90 мм_коррозионностойкий алюминий

# IfcFlowFitting: 260х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:260х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601274
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 260х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 280х180х100 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:280х180х100 мм_коррозионностойкий алюминий:580916
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 280х180х100 мм_коррозионностойкий алюминий

# IfcFlowFitting: 280х230х110 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:280х230х110 мм_коррозионностойкий алюминий:580546
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 280х230х110 мм_коррозионностойкий алюминий

# IfcFlowFitting: 330х230х110 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:330х230х110 мм_коррозионностойкий алюминий:580551
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 330х230х110 мм_коррозионностойкий алюминий

# IfcFlowFitting: 330х230х180 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:330х230х180 мм_коррозионностойкий алюминий:580558
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 330х230х180 мм_коррозионностойкий алюминий

# IfcFlowFitting: 360х160х90 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:360х160х90 мм_коррозионностойкий алюминий:580573
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 360х160х90 мм_коррозионностойкий алюминий

# IfcFlowFitting: 360х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:360х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601275
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 360х160х90 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 400х230х110 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:400х230х110 мм_коррозионностойкий алюминий:580578
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400х230х110 мм_коррозионностойкий алюминий

# IfcFlowFitting: 400х250х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:400х250х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601276
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400х250х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 400х310х110 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:400х310х110 мм_коррозионностойкий алюминий:580583
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400х310х110 мм_коррозионностойкий алюминий

# IfcFlowFitting: 400х310х180 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:400х310х180 мм_коррозионностойкий алюминий:599869
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400х310х180 мм_коррозионностойкий алюминий

# IfcFlowFitting: 400х400х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:400х400х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601277
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 400х400х120 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 600х310х110 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:600х310х110 мм_коррозионностойкий алюминий:599870
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600х310х110 мм_коррозионностойкий алюминий

# IfcFlowFitting: 600х310х180 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:600х310х180 мм_коррозионностойкий алюминий:599897
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 600х310х180 мм_коррозионностойкий алюминий

# IfcFlowFitting: 80х75х56 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита, КНС_ВзрывозащищенныйКорпус_DKC:80х75х56 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита:601268
In: Этаж 01
Type - Material: DKC_Полиэстр_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 80х75х56 мм_ударопрочный полиэстер, армированный стекловолокном, с добавлением графита

# IfcFlowFitting: 80х75х57 мм_коррозионностойкий алюминий, КНС_ВзрывозащищенныйКорпус_DKC:80х75х57 мм_коррозионностойкий алюминий:580244
In: Этаж 01
Type - Material: DKC_Алюминий_Светло-серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_DistributionFlowElementCommon - Reference: 80х75х57 мм_коррозионностойкий алюминий
