Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:27:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:27:10 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{DF87884E-845C-4366-A649-D97F86F3D0B7}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:26:32 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:26:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:26:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 600х1000_Серый, КНС_НапольныйШкаф24U_DKC:600х1000_Серый:663146
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х1000_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2461GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2461GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х1000_Черный, КНС_НапольныйШкаф24U_DKC:600х1000_Черный:663033
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х1000_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2461GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2461GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х1200_Черный, КНС_НапольныйШкаф24U_DKC:600х1200_Черный:663034
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х1200_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2462GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2462GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х600_Серый, КНС_НапольныйШкаф24U_DKC:600х600_Серый:663144
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х600_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2466GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2466GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х600_Черный, КНС_НапольныйШкаф24U_DKC:600х600_Черный:663031
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х600_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2466GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2466GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х800_Серый, КНС_НапольныйШкаф24U_DKC:600х800_Серый:663145
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х800_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2468GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2468GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 600х800_Черный, КНС_НапольныйШкаф24U_DKC:600х800_Черный:663032
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 600х800_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2468GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2468GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1000_Серый, КНС_НапольныйШкаф24U_DKC:800х1000_Серый:663149
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х1000_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2481GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2481GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1000_Черный, КНС_НапольныйШкаф24U_DKC:800х1000_Черный:663036
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х1000_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2481GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2481GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х1200_Черный, КНС_НапольныйШкаф24U_DKC:800х1200_Черный:663037
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х1200_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2482GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2482GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х800_Серый, КНС_НапольныйШкаф24U_DKC:800х800_Серый:663148
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х800_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2488GS; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2488GS/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 800х800_Черный, КНС_НапольныйШкаф24U_DKC:800х800_Черный:663035
In: Этаж 01
Type - Material: DKC_Металл_Серый, DKC_Металл_Черный, DKC_Алюминий_Серый, DKC_Зона обслуживания, DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: 800х800_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5IT2488GSB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5IT2488GSB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002499; Описание: Отличительные особенности и преимущества • распределенная полезная нагрузка 1500 кг; • возможность установки потолочных вентиляционных модулей, не занимающих юниты; • закаленное стекло толщиной 4 мм в раме фронтальной двери; • площадь перфорации дверей 82% для обеспечения надежного охлаждения установленного оборудования; • полная взаимозаменяемость передних и задних дверей; • возможность установки одностворчатых дверей для открытия справа или слева; • лазерная юнитовая разметка 19-дюймовых вертикальных монтажных профилей для легкого позиционирования устанавливаемого оборудования; • поставка в разобранном виде облегчает доставку до места будущего расположения шкафа; • точное позиционирование элементов силового каркаса при сборке обеспечено конструктивно; • поставка шкафа под единым кодом.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: RAL7035 (10)
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: RAL7035
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
Name (КНС_ОрганизаторВоздушныхПотоков_DKC:RAL7035:...) | ADSK_Код изделия
663151 | R5VRU246075
663152 | R5VRU246075
663157 | R5VRU246075
663158 | R5VRU246075
663163 | R5VRU246075
663164 | R5VRU246075
663175 | R5VRU248075
663176 | R5VRU248075
663181 | R5VRU248075
663182 | R5VRU248075

# IfcBuildingElementProxy: RAL9005 (14)
In: Этаж 01
Type - Material: DKC_Сталь_Черный
Pset_BuildingElementProxyCommon - Reference: RAL9005
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002519; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
Name (КНС_ОрганизаторВоздушныхПотоков_DKC:RAL9005:...) | ADSK_Код изделия
663068 | R5VRU246075B
663069 | R5VRU246075B
663074 | R5VRU246075B
663075 | R5VRU246075B
663080 | R5VRU246075B
663081 | R5VRU246075B
663086 | R5VRU246075B
663087 | R5VRU246075B
663092 | R5VRU248075B
663093 | R5VRU248075B
663098 | R5VRU248075B
663099 | R5VRU248075B
663104 | R5VRU248075B
663105 | R5VRU248075B
