Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T16:15:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 16:15:57 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{CD79D42D-EBC7-41DF-B4FE-CC0062374732}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 16:15:56 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 16:15:57 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 16:15:57 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2361.0804.622.04_Исполнение I-0-II, КНС_ПереключательСФиксациейСостоянияКлючом_DKC:2361.0804.622.04_Исполнение I-0-II:591584
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0804.622.04_Исполнение I-0-II
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0804.622.04; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления с фиксацией положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; • комплектуется ключами.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0805.622.01_Исполнение 0–I, КНС_ПереключательСФиксациейСостоянияКлючом_DKC:2361.0805.622.01_Исполнение 0–I:591583
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0805.622.01_Исполнение 0–I
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0805.622.01; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления с фиксацией положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; • комплектуется ключами.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0806.622.04_Исполнение I–0–II, КНС_ПереключательСФиксациейСостоянияКлючом_DKC:2361.0806.622.04_Исполнение I–0–II:591585
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0806.622.04_Исполнение I–0–II
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0806.622.04; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления с фиксацией положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; • комплектуется ключами.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0807.622.05_Исполнение 0–.–I, КНС_ПереключательСФиксациейСостоянияКлючом_DKC:2361.0807.622.05_Исполнение 0–.–I:591586
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0807.622.05_Исполнение 0–.–I
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0807.622.05; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления с фиксацией положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; • комплектуется ключами.; Комментарии к типоразмеру: Взрывозащищита элемент управления

# IfcBuildingElementProxy: 2361.0809.622.10_Исполнение 0-., КНС_ПереключательСФиксациейСостоянияКлючом_DKC:2361.0809.622.10_Исполнение 0-.:591577
In: Этаж 01
Type - Material: DKC_Алюминий_Белый, DKC_Полиамид_Черный
Pset_BuildingElementProxyCommon - Reference: 2361.0809.622.10_Исполнение 0-.
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 2361.0809.622.10; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/vzryvozashchishchennoe-elektrooborudovanie/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/962/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; Описание: Назначение • управляющая насадка-переключатель на контактный блок для замыкания и размыкания электрических цепей управления с фиксацией положения; • устанавливается в подготовленное отверстие и фиксируется гайкой с противоположной стороны. Комплектация • комплектуется гайкой для фиксации на стенке коробки; • не комплектуется контактным блоком; • комплектуется ключами.; Комментарии к типоразмеру: Взрывозащищита элемент управления
