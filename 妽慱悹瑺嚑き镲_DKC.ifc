Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:56:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:56:50 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{DB45CF56-58A5-435B-823B-34BE3B1D9BBE}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:56:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:56:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:56:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 28U 1400мм Ш=600мм, КНС_РамаЗадняя_DKC:28U 1400мм Ш=600мм:761743
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 28U 1400мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CRK1460; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5CRK1460/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 33U 1600мм Ш=600мм, КНС_РамаЗадняя_DKC:33U 1600мм Ш=600мм:761751
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 33U 1600мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CRK1660; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5CRK1660/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 37U 1800мм Ш=600мм, КНС_РамаЗадняя_DKC:37U 1800мм Ш=600мм:761752
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 37U 1800мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CRK1860; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5CRK1860/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 42U 2000мм Ш=600мм, КНС_РамаЗадняя_DKC:42U 2000мм Ш=600мм:761755
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 42U 2000мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CRK2060; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5CRK2060/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: 46U 2200мм Ш=600мм, КНС_РамаЗадняя_DKC:46U 2200мм Ш=600мм:761753
In: Этаж 01
Type - Material: DKC_Сталь_Серый
Pset_BuildingElementProxyCommon - Reference: 46U 2200мм Ш=600мм
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5CRK2260; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/resheniya-dlya-it-infrastruktury-/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5CRK2260/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002517; Описание: Основные характеристики • изготавливается из стали толщиной 1,5 мм; • имеет возможность регулировки по глубине; • угол открытия рамы - 110°, максимальная глубина оборудования – до 300 мм; • поставляется в комплекте с монтажными аксессуарами; • совместима со шкафами высотой 800 и шириной 600 мм; • окрашены методом нанесения полимернопорошкового покрытия RAL 9005 или RAL 7035.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcOpeningElement: Opening (752)
In: Этаж 01
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Name (КНС_РамаЗадняя_DKC:...)
28U 1400мм Ш=600мм:761743:1
28U 1400мм Ш=600мм:761743:2
28U 1400мм Ш=600мм:761743:3
28U 1400мм Ш=600мм:761743:4
28U 1400мм Ш=600мм:761743:5
28U 1400мм Ш=600мм:761743:6
28U 1400мм Ш=600мм:761743:7
28U 1400мм Ш=600мм:761743:8
28U 1400мм Ш=600мм:761743:9
28U 1400мм Ш=600мм:761743:10
28U 1400мм Ш=600мм:761743:11
28U 1400мм Ш=600мм:761743:12
28U 1400мм Ш=600мм:761743:13
28U 1400мм Ш=600мм:761743:14
28U 1400мм Ш=600мм:761743:15
28U 1400мм Ш=600мм:761743:16
28U 1400мм Ш=600мм:761743:17
28U 1400мм Ш=600мм:761743:18
28U 1400мм Ш=600мм:761743:19
28U 1400мм Ш=600мм:761743:20
28U 1400мм Ш=600мм:761743:21
28U 1400мм Ш=600мм:761743:22
28U 1400мм Ш=600мм:761743:23
28U 1400мм Ш=600мм:761743:24
28U 1400мм Ш=600мм:761743:25
28U 1400мм Ш=600мм:761743:26
28U 1400мм Ш=600мм:761743:27
28U 1400мм Ш=600мм:761743:28
28U 1400мм Ш=600мм:761743:29
28U 1400мм Ш=600мм:761743:30
28U 1400мм Ш=600мм:761743:31
28U 1400мм Ш=600мм:761743:32
28U 1400мм Ш=600мм:761743:33
28U 1400мм Ш=600мм:761743:34
28U 1400мм Ш=600мм:761743:35
28U 1400мм Ш=600мм:761743:36
28U 1400мм Ш=600мм:761743:37
28U 1400мм Ш=600мм:761743:38
28U 1400мм Ш=600мм:761743:39
28U 1400мм Ш=600мм:761743:40
28U 1400мм Ш=600мм:761743:41
28U 1400мм Ш=600мм:761743:42
28U 1400мм Ш=600мм:761743:43
28U 1400мм Ш=600мм:761743:44
28U 1400мм Ш=600мм:761743:45
28U 1400мм Ш=600мм:761743:46
28U 1400мм Ш=600мм:761743:47
28U 1400мм Ш=600мм:761743:48
28U 1400мм Ш=600мм:761743:49
28U 1400мм Ш=600мм:761743:50
28U 1400мм Ш=600мм:761743:51
28U 1400мм Ш=600мм:761743:52
28U 1400мм Ш=600мм:761743:53
28U 1400мм Ш=600мм:761743:54
28U 1400мм Ш=600мм:761743:55
28U 1400мм Ш=600мм:761743:56
28U 1400мм Ш=600мм:761743:57
28U 1400мм Ш=600мм:761743:58
28U 1400мм Ш=600мм:761743:59
28U 1400мм Ш=600мм:761743:60
28U 1400мм Ш=600мм:761743:61
28U 1400мм Ш=600мм:761743:62
28U 1400мм Ш=600мм:761743:63
28U 1400мм Ш=600мм:761743:64
28U 1400мм Ш=600мм:761743:65
28U 1400мм Ш=600мм:761743:66
28U 1400мм Ш=600мм:761743:67
28U 1400мм Ш=600мм:761743:68
28U 1400мм Ш=600мм:761743:69
28U 1400мм Ш=600мм:761743:70
28U 1400мм Ш=600мм:761743:71
28U 1400мм Ш=600мм:761743:72
28U 1400мм Ш=600мм:761743:73
28U 1400мм Ш=600мм:761743:74
28U 1400мм Ш=600мм:761743:75
28U 1400мм Ш=600мм:761743:76
28U 1400мм Ш=600мм:761743:77
28U 1400мм Ш=600мм:761743:78
28U 1400мм Ш=600мм:761743:79
28U 1400мм Ш=600мм:761743:80
28U 1400мм Ш=600мм:761743:81
28U 1400мм Ш=600мм:761743:82
28U 1400мм Ш=600мм:761743:83
28U 1400мм Ш=600мм:761743:84
28U 1400мм Ш=600мм:761743:85
28U 1400мм Ш=600мм:761743:86
28U 1400мм Ш=600мм:761743:87
28U 1400мм Ш=600мм:761743:88
28U 1400мм Ш=600мм:761743:89
28U 1400мм Ш=600мм:761743:90
28U 1400мм Ш=600мм:761743:91
28U 1400мм Ш=600мм:761743:92
28U 1400мм Ш=600мм:761743:93
28U 1400мм Ш=600мм:761743:94
28U 1400мм Ш=600мм:761743:95
28U 1400мм Ш=600мм:761743:96
28U 1400мм Ш=600мм:761743:97
28U 1400мм Ш=600мм:761743:98
28U 1400мм Ш=600мм:761743:99
28U 1400мм Ш=600мм:761743:100
28U 1400мм Ш=600мм:761743:101
28U 1400мм Ш=600мм:761743:102
28U 1400мм Ш=600мм:761743:103
28U 1400мм Ш=600мм:761743:104
28U 1400мм Ш=600мм:761743:105
28U 1400мм Ш=600мм:761743:106
28U 1400мм Ш=600мм:761743:107
28U 1400мм Ш=600мм:761743:108
28U 1400мм Ш=600мм:761743:109
28U 1400мм Ш=600мм:761743:110
28U 1400мм Ш=600мм:761743:111
28U 1400мм Ш=600мм:761743:112
33U 1600мм Ш=600мм:761751:1
33U 1600мм Ш=600мм:761751:2
33U 1600мм Ш=600мм:761751:3
33U 1600мм Ш=600мм:761751:4
33U 1600мм Ш=600мм:761751:5
33U 1600мм Ш=600мм:761751:6
33U 1600мм Ш=600мм:761751:7
33U 1600мм Ш=600мм:761751:8
33U 1600мм Ш=600мм:761751:9
33U 1600мм Ш=600мм:761751:10
33U 1600мм Ш=600мм:761751:11
33U 1600мм Ш=600мм:761751:12
33U 1600мм Ш=600мм:761751:13
33U 1600мм Ш=600мм:761751:14
33U 1600мм Ш=600мм:761751:15
33U 1600мм Ш=600мм:761751:16
33U 1600мм Ш=600мм:761751:17
33U 1600мм Ш=600мм:761751:18
33U 1600мм Ш=600мм:761751:19
33U 1600мм Ш=600мм:761751:20
33U 1600мм Ш=600мм:761751:21
33U 1600мм Ш=600мм:761751:22
33U 1600мм Ш=600мм:761751:23
33U 1600мм Ш=600мм:761751:24
33U 1600мм Ш=600мм:761751:25
33U 1600мм Ш=600мм:761751:26
33U 1600мм Ш=600мм:761751:27
33U 1600мм Ш=600мм:761751:28
33U 1600мм Ш=600мм:761751:29
33U 1600мм Ш=600мм:761751:30
33U 1600мм Ш=600мм:761751:31
33U 1600мм Ш=600мм:761751:32
33U 1600мм Ш=600мм:761751:33
33U 1600мм Ш=600мм:761751:34
33U 1600мм Ш=600мм:761751:35
33U 1600мм Ш=600мм:761751:36
33U 1600мм Ш=600мм:761751:37
33U 1600мм Ш=600мм:761751:38
33U 1600мм Ш=600мм:761751:39
33U 1600мм Ш=600мм:761751:40
33U 1600мм Ш=600мм:761751:41
33U 1600мм Ш=600мм:761751:42
33U 1600мм Ш=600мм:761751:43
33U 1600мм Ш=600мм:761751:44
33U 1600мм Ш=600мм:761751:45
33U 1600мм Ш=600мм:761751:46
33U 1600мм Ш=600мм:761751:47
33U 1600мм Ш=600мм:761751:48
33U 1600мм Ш=600мм:761751:49
33U 1600мм Ш=600мм:761751:50
33U 1600мм Ш=600мм:761751:51
33U 1600мм Ш=600мм:761751:52
33U 1600мм Ш=600мм:761751:53
33U 1600мм Ш=600мм:761751:54
33U 1600мм Ш=600мм:761751:55
33U 1600мм Ш=600мм:761751:56
33U 1600мм Ш=600мм:761751:57
33U 1600мм Ш=600мм:761751:58
33U 1600мм Ш=600мм:761751:59
33U 1600мм Ш=600мм:761751:60
33U 1600мм Ш=600мм:761751:61
33U 1600мм Ш=600мм:761751:62
33U 1600мм Ш=600мм:761751:63
33U 1600мм Ш=600мм:761751:64
33U 1600мм Ш=600мм:761751:65
33U 1600мм Ш=600мм:761751:66
33U 1600мм Ш=600мм:761751:67
33U 1600мм Ш=600мм:761751:68
33U 1600мм Ш=600мм:761751:69
33U 1600мм Ш=600мм:761751:70
33U 1600мм Ш=600мм:761751:71
33U 1600мм Ш=600мм:761751:72
33U 1600мм Ш=600мм:761751:73
33U 1600мм Ш=600мм:761751:74
33U 1600мм Ш=600мм:761751:75
33U 1600мм Ш=600мм:761751:76
33U 1600мм Ш=600мм:761751:77
33U 1600мм Ш=600мм:761751:78
33U 1600мм Ш=600мм:761751:79
33U 1600мм Ш=600мм:761751:80
33U 1600мм Ш=600мм:761751:81
33U 1600мм Ш=600мм:761751:82
33U 1600мм Ш=600мм:761751:83
33U 1600мм Ш=600мм:761751:84
33U 1600мм Ш=600мм:761751:85
33U 1600мм Ш=600мм:761751:86
33U 1600мм Ш=600мм:761751:87
33U 1600мм Ш=600мм:761751:88
33U 1600мм Ш=600мм:761751:89
33U 1600мм Ш=600мм:761751:90
33U 1600мм Ш=600мм:761751:91
33U 1600мм Ш=600мм:761751:92
33U 1600мм Ш=600мм:761751:93
33U 1600мм Ш=600мм:761751:94
33U 1600мм Ш=600мм:761751:95
33U 1600мм Ш=600мм:761751:96
33U 1600мм Ш=600мм:761751:97
33U 1600мм Ш=600мм:761751:98
33U 1600мм Ш=600мм:761751:99
33U 1600мм Ш=600мм:761751:100
33U 1600мм Ш=600мм:761751:101
33U 1600мм Ш=600мм:761751:102
33U 1600мм Ш=600мм:761751:103
33U 1600мм Ш=600мм:761751:104
33U 1600мм Ш=600мм:761751:105
33U 1600мм Ш=600мм:761751:106
33U 1600мм Ш=600мм:761751:107
33U 1600мм Ш=600мм:761751:108
33U 1600мм Ш=600мм:761751:109
33U 1600мм Ш=600мм:761751:110
33U 1600мм Ш=600мм:761751:111
33U 1600мм Ш=600мм:761751:112
33U 1600мм Ш=600мм:761751:113
33U 1600мм Ш=600мм:761751:114
33U 1600мм Ш=600мм:761751:115
33U 1600мм Ш=600мм:761751:116
33U 1600мм Ш=600мм:761751:117
33U 1600мм Ш=600мм:761751:118
33U 1600мм Ш=600мм:761751:119
33U 1600мм Ш=600мм:761751:120
33U 1600мм Ш=600мм:761751:121
33U 1600мм Ш=600мм:761751:122
33U 1600мм Ш=600мм:761751:123
33U 1600мм Ш=600мм:761751:124
33U 1600мм Ш=600мм:761751:125
33U 1600мм Ш=600мм:761751:126
33U 1600мм Ш=600мм:761751:127
33U 1600мм Ш=600мм:761751:128
37U 1800мм Ш=600мм:761752:1
37U 1800мм Ш=600мм:761752:2
37U 1800мм Ш=600мм:761752:3
37U 1800мм Ш=600мм:761752:4
37U 1800мм Ш=600мм:761752:5
37U 1800мм Ш=600мм:761752:6
37U 1800мм Ш=600мм:761752:7
37U 1800мм Ш=600мм:761752:8
37U 1800мм Ш=600мм:761752:9
37U 1800мм Ш=600мм:761752:10
37U 1800мм Ш=600мм:761752:11
37U 1800мм Ш=600мм:761752:12
37U 1800мм Ш=600мм:761752:13
37U 1800мм Ш=600мм:761752:14
37U 1800мм Ш=600мм:761752:15
37U 1800мм Ш=600мм:761752:16
37U 1800мм Ш=600мм:761752:17
37U 1800мм Ш=600мм:761752:18
37U 1800мм Ш=600мм:761752:19
37U 1800мм Ш=600мм:761752:20
37U 1800мм Ш=600мм:761752:21
37U 1800мм Ш=600мм:761752:22
37U 1800мм Ш=600мм:761752:23
37U 1800мм Ш=600мм:761752:24
37U 1800мм Ш=600мм:761752:25
37U 1800мм Ш=600мм:761752:26
37U 1800мм Ш=600мм:761752:27
37U 1800мм Ш=600мм:761752:28
37U 1800мм Ш=600мм:761752:29
37U 1800мм Ш=600мм:761752:30
37U 1800мм Ш=600мм:761752:31
37U 1800мм Ш=600мм:761752:32
37U 1800мм Ш=600мм:761752:33
37U 1800мм Ш=600мм:761752:34
37U 1800мм Ш=600мм:761752:35
37U 1800мм Ш=600мм:761752:36
37U 1800мм Ш=600мм:761752:37
37U 1800мм Ш=600мм:761752:38
37U 1800мм Ш=600мм:761752:39
37U 1800мм Ш=600мм:761752:40
37U 1800мм Ш=600мм:761752:41
37U 1800мм Ш=600мм:761752:42
37U 1800мм Ш=600мм:761752:43
37U 1800мм Ш=600мм:761752:44
37U 1800мм Ш=600мм:761752:45
37U 1800мм Ш=600мм:761752:46
37U 1800мм Ш=600мм:761752:47
37U 1800мм Ш=600мм:761752:48
37U 1800мм Ш=600мм:761752:49
37U 1800мм Ш=600мм:761752:50
37U 1800мм Ш=600мм:761752:51
37U 1800мм Ш=600мм:761752:52
37U 1800мм Ш=600мм:761752:53
37U 1800мм Ш=600мм:761752:54
37U 1800мм Ш=600мм:761752:55
37U 1800мм Ш=600мм:761752:56
37U 1800мм Ш=600мм:761752:57
37U 1800мм Ш=600мм:761752:58
37U 1800мм Ш=600мм:761752:59
37U 1800мм Ш=600мм:761752:60
37U 1800мм Ш=600мм:761752:61
37U 1800мм Ш=600мм:761752:62
37U 1800мм Ш=600мм:761752:63
37U 1800мм Ш=600мм:761752:64
37U 1800мм Ш=600мм:761752:65
37U 1800мм Ш=600мм:761752:66
37U 1800мм Ш=600мм:761752:67
37U 1800мм Ш=600мм:761752:68
37U 1800мм Ш=600мм:761752:69
37U 1800мм Ш=600мм:761752:70
37U 1800мм Ш=600мм:761752:71
37U 1800мм Ш=600мм:761752:72
37U 1800мм Ш=600мм:761752:73
37U 1800мм Ш=600мм:761752:74
37U 1800мм Ш=600мм:761752:75
37U 1800мм Ш=600мм:761752:76
37U 1800мм Ш=600мм:761752:77
37U 1800мм Ш=600мм:761752:78
37U 1800мм Ш=600мм:761752:79
37U 1800мм Ш=600мм:761752:80
37U 1800мм Ш=600мм:761752:81
37U 1800мм Ш=600мм:761752:82
37U 1800мм Ш=600мм:761752:83
37U 1800мм Ш=600мм:761752:84
37U 1800мм Ш=600мм:761752:85
37U 1800мм Ш=600мм:761752:86
37U 1800мм Ш=600мм:761752:87
37U 1800мм Ш=600мм:761752:88
37U 1800мм Ш=600мм:761752:89
37U 1800мм Ш=600мм:761752:90
37U 1800мм Ш=600мм:761752:91
37U 1800мм Ш=600мм:761752:92
37U 1800мм Ш=600мм:761752:93
37U 1800мм Ш=600мм:761752:94
37U 1800мм Ш=600мм:761752:95
37U 1800мм Ш=600мм:761752:96
37U 1800мм Ш=600мм:761752:97
37U 1800мм Ш=600мм:761752:98
37U 1800мм Ш=600мм:761752:99
37U 1800мм Ш=600мм:761752:100
37U 1800мм Ш=600мм:761752:101
37U 1800мм Ш=600мм:761752:102
37U 1800мм Ш=600мм:761752:103
37U 1800мм Ш=600мм:761752:104
37U 1800мм Ш=600мм:761752:105
37U 1800мм Ш=600мм:761752:106
37U 1800мм Ш=600мм:761752:107
37U 1800мм Ш=600мм:761752:108
37U 1800мм Ш=600мм:761752:109
37U 1800мм Ш=600мм:761752:110
37U 1800мм Ш=600мм:761752:111
37U 1800мм Ш=600мм:761752:112
37U 1800мм Ш=600мм:761752:113
37U 1800мм Ш=600мм:761752:114
37U 1800мм Ш=600мм:761752:115
37U 1800мм Ш=600мм:761752:116
37U 1800мм Ш=600мм:761752:117
37U 1800мм Ш=600мм:761752:118
37U 1800мм Ш=600мм:761752:119
37U 1800мм Ш=600мм:761752:120
37U 1800мм Ш=600мм:761752:121
37U 1800мм Ш=600мм:761752:122
37U 1800мм Ш=600мм:761752:123
37U 1800мм Ш=600мм:761752:124
37U 1800мм Ш=600мм:761752:125
37U 1800мм Ш=600мм:761752:126
37U 1800мм Ш=600мм:761752:127
37U 1800мм Ш=600мм:761752:128
37U 1800мм Ш=600мм:761752:129
37U 1800мм Ш=600мм:761752:130
37U 1800мм Ш=600мм:761752:131
37U 1800мм Ш=600мм:761752:132
37U 1800мм Ш=600мм:761752:133
37U 1800мм Ш=600мм:761752:134
37U 1800мм Ш=600мм:761752:135
37U 1800мм Ш=600мм:761752:136
37U 1800мм Ш=600мм:761752:137
37U 1800мм Ш=600мм:761752:138
37U 1800мм Ш=600мм:761752:139
37U 1800мм Ш=600мм:761752:140
37U 1800мм Ш=600мм:761752:141
37U 1800мм Ш=600мм:761752:142
37U 1800мм Ш=600мм:761752:143
37U 1800мм Ш=600мм:761752:144
37U 1800мм Ш=600мм:761752:145
37U 1800мм Ш=600мм:761752:146
37U 1800мм Ш=600мм:761752:147
37U 1800мм Ш=600мм:761752:148
37U 1800мм Ш=600мм:761752:149
37U 1800мм Ш=600мм:761752:150
37U 1800мм Ш=600мм:761752:151
37U 1800мм Ш=600мм:761752:152
37U 1800мм Ш=600мм:761752:153
37U 1800мм Ш=600мм:761752:154
37U 1800мм Ш=600мм:761752:155
37U 1800мм Ш=600мм:761752:156
37U 1800мм Ш=600мм:761752:157
37U 1800мм Ш=600мм:761752:158
37U 1800мм Ш=600мм:761752:159
37U 1800мм Ш=600мм:761752:160
37U 1800мм Ш=600мм:761752:161
37U 1800мм Ш=600мм:761752:162
37U 1800мм Ш=600мм:761752:163
37U 1800мм Ш=600мм:761752:164
46U 2200мм Ш=600мм:761753:1
46U 2200мм Ш=600мм:761753:2
46U 2200мм Ш=600мм:761753:3
46U 2200мм Ш=600мм:761753:4
46U 2200мм Ш=600мм:761753:5
46U 2200мм Ш=600мм:761753:6
46U 2200мм Ш=600мм:761753:7
46U 2200мм Ш=600мм:761753:8
46U 2200мм Ш=600мм:761753:9
46U 2200мм Ш=600мм:761753:10
46U 2200мм Ш=600мм:761753:11
46U 2200мм Ш=600мм:761753:12
46U 2200мм Ш=600мм:761753:13
46U 2200мм Ш=600мм:761753:14
46U 2200мм Ш=600мм:761753:15
46U 2200мм Ш=600мм:761753:16
46U 2200мм Ш=600мм:761753:17
46U 2200мм Ш=600мм:761753:18
46U 2200мм Ш=600мм:761753:19
46U 2200мм Ш=600мм:761753:20
46U 2200мм Ш=600мм:761753:21
46U 2200мм Ш=600мм:761753:22
46U 2200мм Ш=600мм:761753:23
46U 2200мм Ш=600мм:761753:24
46U 2200мм Ш=600мм:761753:25
46U 2200мм Ш=600мм:761753:26
46U 2200мм Ш=600мм:761753:27
46U 2200мм Ш=600мм:761753:28
46U 2200мм Ш=600мм:761753:29
46U 2200мм Ш=600мм:761753:30
46U 2200мм Ш=600мм:761753:31
46U 2200мм Ш=600мм:761753:32
46U 2200мм Ш=600мм:761753:33
46U 2200мм Ш=600мм:761753:34
46U 2200мм Ш=600мм:761753:35
46U 2200мм Ш=600мм:761753:36
46U 2200мм Ш=600мм:761753:37
46U 2200мм Ш=600мм:761753:38
46U 2200мм Ш=600мм:761753:39
46U 2200мм Ш=600мм:761753:40
46U 2200мм Ш=600мм:761753:41
46U 2200мм Ш=600мм:761753:42
46U 2200мм Ш=600мм:761753:43
46U 2200мм Ш=600мм:761753:44
46U 2200мм Ш=600мм:761753:45
46U 2200мм Ш=600мм:761753:46
46U 2200мм Ш=600мм:761753:47
46U 2200мм Ш=600мм:761753:48
46U 2200мм Ш=600мм:761753:49
46U 2200мм Ш=600мм:761753:50
46U 2200мм Ш=600мм:761753:51
46U 2200мм Ш=600мм:761753:52
46U 2200мм Ш=600мм:761753:53
46U 2200мм Ш=600мм:761753:54
46U 2200мм Ш=600мм:761753:55
46U 2200мм Ш=600мм:761753:56
46U 2200мм Ш=600мм:761753:57
46U 2200мм Ш=600мм:761753:58
46U 2200мм Ш=600мм:761753:59
46U 2200мм Ш=600мм:761753:60
46U 2200мм Ш=600мм:761753:61
46U 2200мм Ш=600мм:761753:62
46U 2200мм Ш=600мм:761753:63
46U 2200мм Ш=600мм:761753:64
46U 2200мм Ш=600мм:761753:65
46U 2200мм Ш=600мм:761753:66
46U 2200мм Ш=600мм:761753:67
46U 2200мм Ш=600мм:761753:68
46U 2200мм Ш=600мм:761753:69
46U 2200мм Ш=600мм:761753:70
46U 2200мм Ш=600мм:761753:71
46U 2200мм Ш=600мм:761753:72
46U 2200мм Ш=600мм:761753:73
46U 2200мм Ш=600мм:761753:74
46U 2200мм Ш=600мм:761753:75
46U 2200мм Ш=600мм:761753:76
46U 2200мм Ш=600мм:761753:77
46U 2200мм Ш=600мм:761753:78
46U 2200мм Ш=600мм:761753:79
46U 2200мм Ш=600мм:761753:80
46U 2200мм Ш=600мм:761753:81
46U 2200мм Ш=600мм:761753:82
46U 2200мм Ш=600мм:761753:83
46U 2200мм Ш=600мм:761753:84
46U 2200мм Ш=600мм:761753:85
46U 2200мм Ш=600мм:761753:86
46U 2200мм Ш=600мм:761753:87
46U 2200мм Ш=600мм:761753:88
46U 2200мм Ш=600мм:761753:89
46U 2200мм Ш=600мм:761753:90
46U 2200мм Ш=600мм:761753:91
46U 2200мм Ш=600мм:761753:92
46U 2200мм Ш=600мм:761753:93
46U 2200мм Ш=600мм:761753:94
46U 2200мм Ш=600мм:761753:95
46U 2200мм Ш=600мм:761753:96
46U 2200мм Ш=600мм:761753:97
46U 2200мм Ш=600мм:761753:98
46U 2200мм Ш=600мм:761753:99
46U 2200мм Ш=600мм:761753:100
46U 2200мм Ш=600мм:761753:101
46U 2200мм Ш=600мм:761753:102
46U 2200мм Ш=600мм:761753:103
46U 2200мм Ш=600мм:761753:104
46U 2200мм Ш=600мм:761753:105
46U 2200мм Ш=600мм:761753:106
46U 2200мм Ш=600мм:761753:107
46U 2200мм Ш=600мм:761753:108
46U 2200мм Ш=600мм:761753:109
46U 2200мм Ш=600мм:761753:110
46U 2200мм Ш=600мм:761753:111
46U 2200мм Ш=600мм:761753:112
46U 2200мм Ш=600мм:761753:113
46U 2200мм Ш=600мм:761753:114
46U 2200мм Ш=600мм:761753:115
46U 2200мм Ш=600мм:761753:116
46U 2200мм Ш=600мм:761753:117
46U 2200мм Ш=600мм:761753:118
46U 2200мм Ш=600мм:761753:119
46U 2200мм Ш=600мм:761753:120
46U 2200мм Ш=600мм:761753:121
46U 2200мм Ш=600мм:761753:122
46U 2200мм Ш=600мм:761753:123
46U 2200мм Ш=600мм:761753:124
46U 2200мм Ш=600мм:761753:125
46U 2200мм Ш=600мм:761753:126
46U 2200мм Ш=600мм:761753:127
46U 2200мм Ш=600мм:761753:128
46U 2200мм Ш=600мм:761753:129
46U 2200мм Ш=600мм:761753:130
46U 2200мм Ш=600мм:761753:131
46U 2200мм Ш=600мм:761753:132
46U 2200мм Ш=600мм:761753:133
46U 2200мм Ш=600мм:761753:134
46U 2200мм Ш=600мм:761753:135
46U 2200мм Ш=600мм:761753:136
46U 2200мм Ш=600мм:761753:137
46U 2200мм Ш=600мм:761753:138
46U 2200мм Ш=600мм:761753:139
46U 2200мм Ш=600мм:761753:140
46U 2200мм Ш=600мм:761753:141
46U 2200мм Ш=600мм:761753:142
46U 2200мм Ш=600мм:761753:143
46U 2200мм Ш=600мм:761753:144
46U 2200мм Ш=600мм:761753:145
46U 2200мм Ш=600мм:761753:146
46U 2200мм Ш=600мм:761753:147
46U 2200мм Ш=600мм:761753:148
46U 2200мм Ш=600мм:761753:149
46U 2200мм Ш=600мм:761753:150
46U 2200мм Ш=600мм:761753:151
46U 2200мм Ш=600мм:761753:152
46U 2200мм Ш=600мм:761753:153
46U 2200мм Ш=600мм:761753:154
46U 2200мм Ш=600мм:761753:155
46U 2200мм Ш=600мм:761753:156
46U 2200мм Ш=600мм:761753:157
46U 2200мм Ш=600мм:761753:158
46U 2200мм Ш=600мм:761753:159
46U 2200мм Ш=600мм:761753:160
46U 2200мм Ш=600мм:761753:161
46U 2200мм Ш=600мм:761753:162
46U 2200мм Ш=600мм:761753:163
46U 2200мм Ш=600мм:761753:164
46U 2200мм Ш=600мм:761753:165
46U 2200мм Ш=600мм:761753:166
46U 2200мм Ш=600мм:761753:167
46U 2200мм Ш=600мм:761753:168
46U 2200мм Ш=600мм:761753:169
46U 2200мм Ш=600мм:761753:170
46U 2200мм Ш=600мм:761753:171
46U 2200мм Ш=600мм:761753:172
46U 2200мм Ш=600мм:761753:173
46U 2200мм Ш=600мм:761753:174
46U 2200мм Ш=600мм:761753:175
46U 2200мм Ш=600мм:761753:176
46U 2200мм Ш=600мм:761753:177
46U 2200мм Ш=600мм:761753:178
46U 2200мм Ш=600мм:761753:179
46U 2200мм Ш=600мм:761753:180
46U 2200мм Ш=600мм:761753:181
46U 2200мм Ш=600мм:761753:182
46U 2200мм Ш=600мм:761753:183
46U 2200мм Ш=600мм:761753:184
42U 2000мм Ш=600мм:761755:1
42U 2000мм Ш=600мм:761755:2
42U 2000мм Ш=600мм:761755:3
42U 2000мм Ш=600мм:761755:4
42U 2000мм Ш=600мм:761755:5
42U 2000мм Ш=600мм:761755:6
42U 2000мм Ш=600мм:761755:7
42U 2000мм Ш=600мм:761755:8
42U 2000мм Ш=600мм:761755:9
42U 2000мм Ш=600мм:761755:10
42U 2000мм Ш=600мм:761755:11
42U 2000мм Ш=600мм:761755:12
42U 2000мм Ш=600мм:761755:13
42U 2000мм Ш=600мм:761755:14
42U 2000мм Ш=600мм:761755:15
42U 2000мм Ш=600мм:761755:16
42U 2000мм Ш=600мм:761755:17
42U 2000мм Ш=600мм:761755:18
42U 2000мм Ш=600мм:761755:19
42U 2000мм Ш=600мм:761755:20
42U 2000мм Ш=600мм:761755:21
42U 2000мм Ш=600мм:761755:22
42U 2000мм Ш=600мм:761755:23
42U 2000мм Ш=600мм:761755:24
42U 2000мм Ш=600мм:761755:25
42U 2000мм Ш=600мм:761755:26
42U 2000мм Ш=600мм:761755:27
42U 2000мм Ш=600мм:761755:28
42U 2000мм Ш=600мм:761755:29
42U 2000мм Ш=600мм:761755:30
42U 2000мм Ш=600мм:761755:31
42U 2000мм Ш=600мм:761755:32
42U 2000мм Ш=600мм:761755:33
42U 2000мм Ш=600мм:761755:34
42U 2000мм Ш=600мм:761755:35
42U 2000мм Ш=600мм:761755:36
42U 2000мм Ш=600мм:761755:37
42U 2000мм Ш=600мм:761755:38
42U 2000мм Ш=600мм:761755:39
42U 2000мм Ш=600мм:761755:40
42U 2000мм Ш=600мм:761755:41
42U 2000мм Ш=600мм:761755:42
42U 2000мм Ш=600мм:761755:43
42U 2000мм Ш=600мм:761755:44
42U 2000мм Ш=600мм:761755:45
42U 2000мм Ш=600мм:761755:46
42U 2000мм Ш=600мм:761755:47
42U 2000мм Ш=600мм:761755:48
42U 2000мм Ш=600мм:761755:49
42U 2000мм Ш=600мм:761755:50
42U 2000мм Ш=600мм:761755:51
42U 2000мм Ш=600мм:761755:52
42U 2000мм Ш=600мм:761755:53
42U 2000мм Ш=600мм:761755:54
42U 2000мм Ш=600мм:761755:55
42U 2000мм Ш=600мм:761755:56
42U 2000мм Ш=600мм:761755:57
42U 2000мм Ш=600мм:761755:58
42U 2000мм Ш=600мм:761755:59
42U 2000мм Ш=600мм:761755:60
42U 2000мм Ш=600мм:761755:61
42U 2000мм Ш=600мм:761755:62
42U 2000мм Ш=600мм:761755:63
42U 2000мм Ш=600мм:761755:64
42U 2000мм Ш=600мм:761755:65
42U 2000мм Ш=600мм:761755:66
42U 2000мм Ш=600мм:761755:67
42U 2000мм Ш=600мм:761755:68
42U 2000мм Ш=600мм:761755:69
42U 2000мм Ш=600мм:761755:70
42U 2000мм Ш=600мм:761755:71
42U 2000мм Ш=600мм:761755:72
42U 2000мм Ш=600мм:761755:73
42U 2000мм Ш=600мм:761755:74
42U 2000мм Ш=600мм:761755:75
42U 2000мм Ш=600мм:761755:76
42U 2000мм Ш=600мм:761755:77
42U 2000мм Ш=600мм:761755:78
42U 2000мм Ш=600мм:761755:79
42U 2000мм Ш=600мм:761755:80
42U 2000мм Ш=600мм:761755:81
42U 2000мм Ш=600мм:761755:82
42U 2000мм Ш=600мм:761755:83
42U 2000мм Ш=600мм:761755:84
42U 2000мм Ш=600мм:761755:85
42U 2000мм Ш=600мм:761755:86
42U 2000мм Ш=600мм:761755:87
42U 2000мм Ш=600мм:761755:88
42U 2000мм Ш=600мм:761755:89
42U 2000мм Ш=600мм:761755:90
42U 2000мм Ш=600мм:761755:91
42U 2000мм Ш=600мм:761755:92
42U 2000мм Ш=600мм:761755:93
42U 2000мм Ш=600мм:761755:94
42U 2000мм Ш=600мм:761755:95
42U 2000мм Ш=600мм:761755:96
42U 2000мм Ш=600мм:761755:97
42U 2000мм Ш=600мм:761755:98
42U 2000мм Ш=600мм:761755:99
42U 2000мм Ш=600мм:761755:100
42U 2000мм Ш=600мм:761755:101
42U 2000мм Ш=600мм:761755:102
42U 2000мм Ш=600мм:761755:103
42U 2000мм Ш=600мм:761755:104
42U 2000мм Ш=600мм:761755:105
42U 2000мм Ш=600мм:761755:106
42U 2000мм Ш=600мм:761755:107
42U 2000мм Ш=600мм:761755:108
42U 2000мм Ш=600мм:761755:109
42U 2000мм Ш=600мм:761755:110
42U 2000мм Ш=600мм:761755:111
42U 2000мм Ш=600мм:761755:112
42U 2000мм Ш=600мм:761755:113
42U 2000мм Ш=600мм:761755:114
42U 2000мм Ш=600мм:761755:115
42U 2000мм Ш=600мм:761755:116
42U 2000мм Ш=600мм:761755:117
42U 2000мм Ш=600мм:761755:118
42U 2000мм Ш=600мм:761755:119
42U 2000мм Ш=600мм:761755:120
42U 2000мм Ш=600мм:761755:121
42U 2000мм Ш=600мм:761755:122
42U 2000мм Ш=600мм:761755:123
42U 2000мм Ш=600мм:761755:124
42U 2000мм Ш=600мм:761755:125
42U 2000мм Ш=600мм:761755:126
42U 2000мм Ш=600мм:761755:127
42U 2000мм Ш=600мм:761755:128
42U 2000мм Ш=600мм:761755:129
42U 2000мм Ш=600мм:761755:130
42U 2000мм Ш=600мм:761755:131
42U 2000мм Ш=600мм:761755:132
42U 2000мм Ш=600мм:761755:133
42U 2000мм Ш=600мм:761755:134
42U 2000мм Ш=600мм:761755:135
42U 2000мм Ш=600мм:761755:136
42U 2000мм Ш=600мм:761755:137
42U 2000мм Ш=600мм:761755:138
42U 2000мм Ш=600мм:761755:139
42U 2000мм Ш=600мм:761755:140
42U 2000мм Ш=600мм:761755:141
42U 2000мм Ш=600мм:761755:142
42U 2000мм Ш=600мм:761755:143
42U 2000мм Ш=600мм:761755:144
42U 2000мм Ш=600мм:761755:145
42U 2000мм Ш=600мм:761755:146
42U 2000мм Ш=600мм:761755:147
42U 2000мм Ш=600мм:761755:148
42U 2000мм Ш=600мм:761755:149
42U 2000мм Ш=600мм:761755:150
42U 2000мм Ш=600мм:761755:151
42U 2000мм Ш=600мм:761755:152
42U 2000мм Ш=600мм:761755:153
42U 2000мм Ш=600мм:761755:154
42U 2000мм Ш=600мм:761755:155
42U 2000мм Ш=600мм:761755:156
42U 2000мм Ш=600мм:761755:157
42U 2000мм Ш=600мм:761755:158
42U 2000мм Ш=600мм:761755:159
42U 2000мм Ш=600мм:761755:160
42U 2000мм Ш=600мм:761755:161
42U 2000мм Ш=600мм:761755:162
42U 2000мм Ш=600мм:761755:163
42U 2000мм Ш=600мм:761755:164
