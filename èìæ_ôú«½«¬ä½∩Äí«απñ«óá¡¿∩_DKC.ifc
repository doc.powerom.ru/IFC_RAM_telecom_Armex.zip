Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-30T15:42:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 30 15:42:42 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F8D11EBD-BB6F-43B1-9A4C-990C2E274202}\ifc * Database version: 5507 * Database creation date: Tue Nov 30 15:42:41 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 30 15:42:41 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 30 15:42:41 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: L253мм C профиль для 600, КНС_УголокДляОборудования_DKC:L253мм C профиль для 600:734888
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L253мм C профиль для 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITC600; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITC600/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 600 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L253мм L профиль для 600, КНС_УголокДляОборудования_DKC:L253мм L профиль для 600:734976
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L253мм L профиль для 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITL600; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITL600/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 800 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на L-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L253мм для 600, КНС_УголокДляОборудования_DKC:L253мм для 600:734271
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L253мм для 600
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITU600; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITU600/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 600 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L453мм C профиль для 800, КНС_УголокДляОборудования_DKC:L453мм C профиль для 800:734889
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L453мм C профиль для 800
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITC800; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITC800/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 800 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L453мм L профиль для 800, КНС_УголокДляОборудования_DKC:L453мм L профиль для 800:734977
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L453мм L профиль для 800
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITL800; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITL800/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 800 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L453мм для 800, КНС_УголокДляОборудования_DKC:L453мм для 800:734575
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L453мм для 800
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITU800; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITU800/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 800 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L653мм C профиль для 1000, КНС_УголокДляОборудования_DKC:L653мм C профиль для 1000:734890
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L653мм C профиль для 1000
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITC1000; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITC1000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 1000 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L653мм L профиль для 1000, КНС_УголокДляОборудования_DKC:L653мм L профиль для 1000:734978
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L653мм L профиль для 1000
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITL1000; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITL1000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 1000 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L653мм для 1000, КНС_УголокДляОборудования_DKC:L653мм для 1000:734583
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L653мм для 1000
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITU1000; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITU1000/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 1000 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L853мм L профиль для 1200, КНС_УголокДляОборудования_DKC:L853мм L профиль для 1200:735053
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L853мм L профиль для 1200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITL1200; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITL1200/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 1200 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на L-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения

# IfcBuildingElementProxy: L853мм для 1200, КНС_УголокДляОборудования_DKC:L853мм для 1200:734591
In: Этаж 01
Type - Material: DKC_Сталь_Нержавеющая_Оцинкованная
Pset_BuildingElementProxyCommon - Reference: L853мм для 1200
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: R5GFITU1200; ADSK_URL документации изделия: https://www.dkc.ru/upload/dkc/pub/Downloads/Catalog/35/Solutions_for_automation_and_IT/catalog_IT_solutions_small.pdf; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/723/R5GFITU1200/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.ru/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрооборудование; ETIM Article Class: EC002625; Описание: Уголки применяются для установки тяжелого оборудования используются со шкафами "RAM telecom". Они незаменимы при монтаже оборудования, имеющего только фронтальное крепление, т.к. позволяют добиться равномерного распределения нагрузки. Уголки размещаются в шкафу глубиной 1200 мм. Максимальная статическая нагрузка - 150 кг. Уголки размещаются на С-образных профилях. Они поставляютися в комплекте из двух штук и монтажных элементов. Материал - оцинкованная сталь толщиной 2,5 мм.; Комментарии к типоразмеру: RAM telecom – Напольные корпусные решения
